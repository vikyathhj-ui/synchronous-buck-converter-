v {xschem version=3.4.7RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}

C {devices/iopin.sym} -600 0 0 0 {name=p0 lab=top}
C {devices/iopin.sym} -600 40 0 0 {name=p1 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 0 0 0 {name=R0 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 -30.0 0 0 {name=l0 lab=n1}
C {devices/lab_pin.sym} 0.0 30.0 0 0 {name=l1 lab=vss}
C {devices/lab_pin.sym} -20.0 0.0 0 0 {name=l2 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 0 0 0 {name=R1 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 -30.0 0 0 {name=l3 lab=n2}
C {devices/lab_pin.sym} 300.0 30.0 0 0 {name=l4 lab=n1}
C {devices/lab_pin.sym} 280.0 0.0 0 0 {name=l5 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 0 0 0 {name=R2 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 -30.0 0 0 {name=l6 lab=n3}
C {devices/lab_pin.sym} 600.0 30.0 0 0 {name=l7 lab=n2}
C {devices/lab_pin.sym} 580.0 0.0 0 0 {name=l8 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 0 0 0 {name=R3 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 -30.0 0 0 {name=l9 lab=n4}
C {devices/lab_pin.sym} 900.0 30.0 0 0 {name=l10 lab=n3}
C {devices/lab_pin.sym} 880.0 0.0 0 0 {name=l11 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 0 0 0 {name=R4 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 -30.0 0 0 {name=l12 lab=n5}
C {devices/lab_pin.sym} 1200.0 30.0 0 0 {name=l13 lab=n4}
C {devices/lab_pin.sym} 1180.0 0.0 0 0 {name=l14 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 0 0 0 {name=R5 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 -30.0 0 0 {name=l15 lab=n6}
C {devices/lab_pin.sym} 1500.0 30.0 0 0 {name=l16 lab=n5}
C {devices/lab_pin.sym} 1480.0 0.0 0 0 {name=l17 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 300 0 0 {name=R6 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 270.0 0 0 {name=l18 lab=n7}
C {devices/lab_pin.sym} 0.0 330.0 0 0 {name=l19 lab=n6}
C {devices/lab_pin.sym} -20.0 300.0 0 0 {name=l20 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 300 0 0 {name=R7 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 270.0 0 0 {name=l21 lab=n8}
C {devices/lab_pin.sym} 300.0 330.0 0 0 {name=l22 lab=n7}
C {devices/lab_pin.sym} 280.0 300.0 0 0 {name=l23 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 300 0 0 {name=R8 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 270.0 0 0 {name=l24 lab=n9}
C {devices/lab_pin.sym} 600.0 330.0 0 0 {name=l25 lab=n8}
C {devices/lab_pin.sym} 580.0 300.0 0 0 {name=l26 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 300 0 0 {name=R9 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 270.0 0 0 {name=l27 lab=n10}
C {devices/lab_pin.sym} 900.0 330.0 0 0 {name=l28 lab=n9}
C {devices/lab_pin.sym} 880.0 300.0 0 0 {name=l29 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 300 0 0 {name=R10 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 270.0 0 0 {name=l30 lab=n11}
C {devices/lab_pin.sym} 1200.0 330.0 0 0 {name=l31 lab=n10}
C {devices/lab_pin.sym} 1180.0 300.0 0 0 {name=l32 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 300 0 0 {name=R11 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 270.0 0 0 {name=l33 lab=n12}
C {devices/lab_pin.sym} 1500.0 330.0 0 0 {name=l34 lab=n11}
C {devices/lab_pin.sym} 1480.0 300.0 0 0 {name=l35 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 600 0 0 {name=R12 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 570.0 0 0 {name=l36 lab=n13}
C {devices/lab_pin.sym} 0.0 630.0 0 0 {name=l37 lab=n12}
C {devices/lab_pin.sym} -20.0 600.0 0 0 {name=l38 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 600 0 0 {name=R13 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 570.0 0 0 {name=l39 lab=n14}
C {devices/lab_pin.sym} 300.0 630.0 0 0 {name=l40 lab=n13}
C {devices/lab_pin.sym} 280.0 600.0 0 0 {name=l41 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 600 0 0 {name=R14 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 570.0 0 0 {name=l42 lab=n15}
C {devices/lab_pin.sym} 600.0 630.0 0 0 {name=l43 lab=n14}
C {devices/lab_pin.sym} 580.0 600.0 0 0 {name=l44 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 600 0 0 {name=R15 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 570.0 0 0 {name=l45 lab=n16}
C {devices/lab_pin.sym} 900.0 630.0 0 0 {name=l46 lab=n15}
C {devices/lab_pin.sym} 880.0 600.0 0 0 {name=l47 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 600 0 0 {name=R16 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 570.0 0 0 {name=l48 lab=n17}
C {devices/lab_pin.sym} 1200.0 630.0 0 0 {name=l49 lab=n16}
C {devices/lab_pin.sym} 1180.0 600.0 0 0 {name=l50 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 600 0 0 {name=R17 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 570.0 0 0 {name=l51 lab=n18}
C {devices/lab_pin.sym} 1500.0 630.0 0 0 {name=l52 lab=n17}
C {devices/lab_pin.sym} 1480.0 600.0 0 0 {name=l53 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 900 0 0 {name=R18 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 870.0 0 0 {name=l54 lab=n19}
C {devices/lab_pin.sym} 0.0 930.0 0 0 {name=l55 lab=n18}
C {devices/lab_pin.sym} -20.0 900.0 0 0 {name=l56 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 900 0 0 {name=R19 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 870.0 0 0 {name=l57 lab=n20}
C {devices/lab_pin.sym} 300.0 930.0 0 0 {name=l58 lab=n19}
C {devices/lab_pin.sym} 280.0 900.0 0 0 {name=l59 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 900 0 0 {name=R20 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 870.0 0 0 {name=l60 lab=n21}
C {devices/lab_pin.sym} 600.0 930.0 0 0 {name=l61 lab=n20}
C {devices/lab_pin.sym} 580.0 900.0 0 0 {name=l62 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 900 0 0 {name=R21 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 870.0 0 0 {name=l63 lab=n22}
C {devices/lab_pin.sym} 900.0 930.0 0 0 {name=l64 lab=n21}
C {devices/lab_pin.sym} 880.0 900.0 0 0 {name=l65 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 900 0 0 {name=R22 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 870.0 0 0 {name=l66 lab=n23}
C {devices/lab_pin.sym} 1200.0 930.0 0 0 {name=l67 lab=n22}
C {devices/lab_pin.sym} 1180.0 900.0 0 0 {name=l68 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 900 0 0 {name=R23 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 870.0 0 0 {name=l69 lab=n24}
C {devices/lab_pin.sym} 1500.0 930.0 0 0 {name=l70 lab=n23}
C {devices/lab_pin.sym} 1480.0 900.0 0 0 {name=l71 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 1200 0 0 {name=R24 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 1170.0 0 0 {name=l72 lab=n25}
C {devices/lab_pin.sym} 0.0 1230.0 0 0 {name=l73 lab=n24}
C {devices/lab_pin.sym} -20.0 1200.0 0 0 {name=l74 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 1200 0 0 {name=R25 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 1170.0 0 0 {name=l75 lab=n26}
C {devices/lab_pin.sym} 300.0 1230.0 0 0 {name=l76 lab=n25}
C {devices/lab_pin.sym} 280.0 1200.0 0 0 {name=l77 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 1200 0 0 {name=R26 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 1170.0 0 0 {name=l78 lab=n27}
C {devices/lab_pin.sym} 600.0 1230.0 0 0 {name=l79 lab=n26}
C {devices/lab_pin.sym} 580.0 1200.0 0 0 {name=l80 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 1200 0 0 {name=R27 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 1170.0 0 0 {name=l81 lab=n28}
C {devices/lab_pin.sym} 900.0 1230.0 0 0 {name=l82 lab=n27}
C {devices/lab_pin.sym} 880.0 1200.0 0 0 {name=l83 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 1200 0 0 {name=R28 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 1170.0 0 0 {name=l84 lab=n29}
C {devices/lab_pin.sym} 1200.0 1230.0 0 0 {name=l85 lab=n28}
C {devices/lab_pin.sym} 1180.0 1200.0 0 0 {name=l86 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 1200 0 0 {name=R29 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 1170.0 0 0 {name=l87 lab=n30}
C {devices/lab_pin.sym} 1500.0 1230.0 0 0 {name=l88 lab=n29}
C {devices/lab_pin.sym} 1480.0 1200.0 0 0 {name=l89 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 1500 0 0 {name=R30 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 1470.0 0 0 {name=l90 lab=n31}
C {devices/lab_pin.sym} 0.0 1530.0 0 0 {name=l91 lab=n30}
C {devices/lab_pin.sym} -20.0 1500.0 0 0 {name=l92 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 1500 0 0 {name=R31 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 1470.0 0 0 {name=l93 lab=n32}
C {devices/lab_pin.sym} 300.0 1530.0 0 0 {name=l94 lab=n31}
C {devices/lab_pin.sym} 280.0 1500.0 0 0 {name=l95 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 1500 0 0 {name=R32 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 1470.0 0 0 {name=l96 lab=n33}
C {devices/lab_pin.sym} 600.0 1530.0 0 0 {name=l97 lab=n32}
C {devices/lab_pin.sym} 580.0 1500.0 0 0 {name=l98 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 1500 0 0 {name=R33 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 1470.0 0 0 {name=l99 lab=n34}
C {devices/lab_pin.sym} 900.0 1530.0 0 0 {name=l100 lab=n33}
C {devices/lab_pin.sym} 880.0 1500.0 0 0 {name=l101 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 1500 0 0 {name=R34 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 1470.0 0 0 {name=l102 lab=n35}
C {devices/lab_pin.sym} 1200.0 1530.0 0 0 {name=l103 lab=n34}
C {devices/lab_pin.sym} 1180.0 1500.0 0 0 {name=l104 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 1500 0 0 {name=R35 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 1470.0 0 0 {name=l105 lab=n36}
C {devices/lab_pin.sym} 1500.0 1530.0 0 0 {name=l106 lab=n35}
C {devices/lab_pin.sym} 1480.0 1500.0 0 0 {name=l107 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 1800 0 0 {name=R36 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 1770.0 0 0 {name=l108 lab=n37}
C {devices/lab_pin.sym} 0.0 1830.0 0 0 {name=l109 lab=n36}
C {devices/lab_pin.sym} -20.0 1800.0 0 0 {name=l110 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 1800 0 0 {name=R37 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 1770.0 0 0 {name=l111 lab=n38}
C {devices/lab_pin.sym} 300.0 1830.0 0 0 {name=l112 lab=n37}
C {devices/lab_pin.sym} 280.0 1800.0 0 0 {name=l113 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 1800 0 0 {name=R38 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 1770.0 0 0 {name=l114 lab=n39}
C {devices/lab_pin.sym} 600.0 1830.0 0 0 {name=l115 lab=n38}
C {devices/lab_pin.sym} 580.0 1800.0 0 0 {name=l116 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 1800 0 0 {name=R39 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 1770.0 0 0 {name=l117 lab=n40}
C {devices/lab_pin.sym} 900.0 1830.0 0 0 {name=l118 lab=n39}
C {devices/lab_pin.sym} 880.0 1800.0 0 0 {name=l119 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 1800 0 0 {name=R40 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 1770.0 0 0 {name=l120 lab=n41}
C {devices/lab_pin.sym} 1200.0 1830.0 0 0 {name=l121 lab=n40}
C {devices/lab_pin.sym} 1180.0 1800.0 0 0 {name=l122 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 1800 0 0 {name=R41 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 1770.0 0 0 {name=l123 lab=n42}
C {devices/lab_pin.sym} 1500.0 1830.0 0 0 {name=l124 lab=n41}
C {devices/lab_pin.sym} 1480.0 1800.0 0 0 {name=l125 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 2100 0 0 {name=R42 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 2070.0 0 0 {name=l126 lab=n43}
C {devices/lab_pin.sym} 0.0 2130.0 0 0 {name=l127 lab=n42}
C {devices/lab_pin.sym} -20.0 2100.0 0 0 {name=l128 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 2100 0 0 {name=R43 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 2070.0 0 0 {name=l129 lab=n44}
C {devices/lab_pin.sym} 300.0 2130.0 0 0 {name=l130 lab=n43}
C {devices/lab_pin.sym} 280.0 2100.0 0 0 {name=l131 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 2100 0 0 {name=R44 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 2070.0 0 0 {name=l132 lab=n45}
C {devices/lab_pin.sym} 600.0 2130.0 0 0 {name=l133 lab=n44}
C {devices/lab_pin.sym} 580.0 2100.0 0 0 {name=l134 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 2100 0 0 {name=R45 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 2070.0 0 0 {name=l135 lab=n46}
C {devices/lab_pin.sym} 900.0 2130.0 0 0 {name=l136 lab=n45}
C {devices/lab_pin.sym} 880.0 2100.0 0 0 {name=l137 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 2100 0 0 {name=R46 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 2070.0 0 0 {name=l138 lab=n47}
C {devices/lab_pin.sym} 1200.0 2130.0 0 0 {name=l139 lab=n46}
C {devices/lab_pin.sym} 1180.0 2100.0 0 0 {name=l140 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 2100 0 0 {name=R47 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 2070.0 0 0 {name=l141 lab=n48}
C {devices/lab_pin.sym} 1500.0 2130.0 0 0 {name=l142 lab=n47}
C {devices/lab_pin.sym} 1480.0 2100.0 0 0 {name=l143 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 2400 0 0 {name=R48 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 2370.0 0 0 {name=l144 lab=n49}
C {devices/lab_pin.sym} 0.0 2430.0 0 0 {name=l145 lab=n48}
C {devices/lab_pin.sym} -20.0 2400.0 0 0 {name=l146 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 2400 0 0 {name=R49 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 2370.0 0 0 {name=l147 lab=n50}
C {devices/lab_pin.sym} 300.0 2430.0 0 0 {name=l148 lab=n49}
C {devices/lab_pin.sym} 280.0 2400.0 0 0 {name=l149 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 2400 0 0 {name=R50 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 2370.0 0 0 {name=l150 lab=n51}
C {devices/lab_pin.sym} 600.0 2430.0 0 0 {name=l151 lab=n50}
C {devices/lab_pin.sym} 580.0 2400.0 0 0 {name=l152 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 2400 0 0 {name=R51 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 2370.0 0 0 {name=l153 lab=n52}
C {devices/lab_pin.sym} 900.0 2430.0 0 0 {name=l154 lab=n51}
C {devices/lab_pin.sym} 880.0 2400.0 0 0 {name=l155 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 2400 0 0 {name=R52 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 2370.0 0 0 {name=l156 lab=n53}
C {devices/lab_pin.sym} 1200.0 2430.0 0 0 {name=l157 lab=n52}
C {devices/lab_pin.sym} 1180.0 2400.0 0 0 {name=l158 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 2400 0 0 {name=R53 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 2370.0 0 0 {name=l159 lab=n54}
C {devices/lab_pin.sym} 1500.0 2430.0 0 0 {name=l160 lab=n53}
C {devices/lab_pin.sym} 1480.0 2400.0 0 0 {name=l161 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 2700 0 0 {name=R54 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 2670.0 0 0 {name=l162 lab=n55}
C {devices/lab_pin.sym} 0.0 2730.0 0 0 {name=l163 lab=n54}
C {devices/lab_pin.sym} -20.0 2700.0 0 0 {name=l164 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 2700 0 0 {name=R55 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 2670.0 0 0 {name=l165 lab=n56}
C {devices/lab_pin.sym} 300.0 2730.0 0 0 {name=l166 lab=n55}
C {devices/lab_pin.sym} 280.0 2700.0 0 0 {name=l167 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 2700 0 0 {name=R56 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 2670.0 0 0 {name=l168 lab=n57}
C {devices/lab_pin.sym} 600.0 2730.0 0 0 {name=l169 lab=n56}
C {devices/lab_pin.sym} 580.0 2700.0 0 0 {name=l170 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 2700 0 0 {name=R57 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 2670.0 0 0 {name=l171 lab=n58}
C {devices/lab_pin.sym} 900.0 2730.0 0 0 {name=l172 lab=n57}
C {devices/lab_pin.sym} 880.0 2700.0 0 0 {name=l173 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 2700 0 0 {name=R58 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 2670.0 0 0 {name=l174 lab=n59}
C {devices/lab_pin.sym} 1200.0 2730.0 0 0 {name=l175 lab=n58}
C {devices/lab_pin.sym} 1180.0 2700.0 0 0 {name=l176 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 2700 0 0 {name=R59 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 2670.0 0 0 {name=l177 lab=n60}
C {devices/lab_pin.sym} 1500.0 2730.0 0 0 {name=l178 lab=n59}
C {devices/lab_pin.sym} 1480.0 2700.0 0 0 {name=l179 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 3000 0 0 {name=R60 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 2970.0 0 0 {name=l180 lab=n61}
C {devices/lab_pin.sym} 0.0 3030.0 0 0 {name=l181 lab=n60}
C {devices/lab_pin.sym} -20.0 3000.0 0 0 {name=l182 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 3000 0 0 {name=R61 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 2970.0 0 0 {name=l183 lab=n62}
C {devices/lab_pin.sym} 300.0 3030.0 0 0 {name=l184 lab=n61}
C {devices/lab_pin.sym} 280.0 3000.0 0 0 {name=l185 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 3000 0 0 {name=R62 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 2970.0 0 0 {name=l186 lab=n63}
C {devices/lab_pin.sym} 600.0 3030.0 0 0 {name=l187 lab=n62}
C {devices/lab_pin.sym} 580.0 3000.0 0 0 {name=l188 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 3000 0 0 {name=R63 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 2970.0 0 0 {name=l189 lab=n64}
C {devices/lab_pin.sym} 900.0 3030.0 0 0 {name=l190 lab=n63}
C {devices/lab_pin.sym} 880.0 3000.0 0 0 {name=l191 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 3000 0 0 {name=R64 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 2970.0 0 0 {name=l192 lab=n65}
C {devices/lab_pin.sym} 1200.0 3030.0 0 0 {name=l193 lab=n64}
C {devices/lab_pin.sym} 1180.0 3000.0 0 0 {name=l194 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 3000 0 0 {name=R65 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 2970.0 0 0 {name=l195 lab=n66}
C {devices/lab_pin.sym} 1500.0 3030.0 0 0 {name=l196 lab=n65}
C {devices/lab_pin.sym} 1480.0 3000.0 0 0 {name=l197 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 3300 0 0 {name=R66 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 3270.0 0 0 {name=l198 lab=n67}
C {devices/lab_pin.sym} 0.0 3330.0 0 0 {name=l199 lab=n66}
C {devices/lab_pin.sym} -20.0 3300.0 0 0 {name=l200 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 3300 0 0 {name=R67 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 3270.0 0 0 {name=l201 lab=n68}
C {devices/lab_pin.sym} 300.0 3330.0 0 0 {name=l202 lab=n67}
C {devices/lab_pin.sym} 280.0 3300.0 0 0 {name=l203 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 3300 0 0 {name=R68 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 3270.0 0 0 {name=l204 lab=n69}
C {devices/lab_pin.sym} 600.0 3330.0 0 0 {name=l205 lab=n68}
C {devices/lab_pin.sym} 580.0 3300.0 0 0 {name=l206 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 3300 0 0 {name=R69 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 3270.0 0 0 {name=l207 lab=n70}
C {devices/lab_pin.sym} 900.0 3330.0 0 0 {name=l208 lab=n69}
C {devices/lab_pin.sym} 880.0 3300.0 0 0 {name=l209 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 3300 0 0 {name=R70 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 3270.0 0 0 {name=l210 lab=n71}
C {devices/lab_pin.sym} 1200.0 3330.0 0 0 {name=l211 lab=n70}
C {devices/lab_pin.sym} 1180.0 3300.0 0 0 {name=l212 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 3300 0 0 {name=R71 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 3270.0 0 0 {name=l213 lab=n72}
C {devices/lab_pin.sym} 1500.0 3330.0 0 0 {name=l214 lab=n71}
C {devices/lab_pin.sym} 1480.0 3300.0 0 0 {name=l215 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 3600 0 0 {name=R72 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 3570.0 0 0 {name=l216 lab=n73}
C {devices/lab_pin.sym} 0.0 3630.0 0 0 {name=l217 lab=n72}
C {devices/lab_pin.sym} -20.0 3600.0 0 0 {name=l218 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 3600 0 0 {name=R73 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 3570.0 0 0 {name=l219 lab=n74}
C {devices/lab_pin.sym} 300.0 3630.0 0 0 {name=l220 lab=n73}
C {devices/lab_pin.sym} 280.0 3600.0 0 0 {name=l221 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 3600 0 0 {name=R74 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 3570.0 0 0 {name=l222 lab=n75}
C {devices/lab_pin.sym} 600.0 3630.0 0 0 {name=l223 lab=n74}
C {devices/lab_pin.sym} 580.0 3600.0 0 0 {name=l224 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 3600 0 0 {name=R75 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 3570.0 0 0 {name=l225 lab=n76}
C {devices/lab_pin.sym} 900.0 3630.0 0 0 {name=l226 lab=n75}
C {devices/lab_pin.sym} 880.0 3600.0 0 0 {name=l227 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 3600 0 0 {name=R76 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 3570.0 0 0 {name=l228 lab=n77}
C {devices/lab_pin.sym} 1200.0 3630.0 0 0 {name=l229 lab=n76}
C {devices/lab_pin.sym} 1180.0 3600.0 0 0 {name=l230 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 3600 0 0 {name=R77 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 3570.0 0 0 {name=l231 lab=n78}
C {devices/lab_pin.sym} 1500.0 3630.0 0 0 {name=l232 lab=n77}
C {devices/lab_pin.sym} 1480.0 3600.0 0 0 {name=l233 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 3900 0 0 {name=R78 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 3870.0 0 0 {name=l234 lab=n79}
C {devices/lab_pin.sym} 0.0 3930.0 0 0 {name=l235 lab=n78}
C {devices/lab_pin.sym} -20.0 3900.0 0 0 {name=l236 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 3900 0 0 {name=R79 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 3870.0 0 0 {name=l237 lab=n80}
C {devices/lab_pin.sym} 300.0 3930.0 0 0 {name=l238 lab=n79}
C {devices/lab_pin.sym} 280.0 3900.0 0 0 {name=l239 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 3900 0 0 {name=R80 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 3870.0 0 0 {name=l240 lab=n81}
C {devices/lab_pin.sym} 600.0 3930.0 0 0 {name=l241 lab=n80}
C {devices/lab_pin.sym} 580.0 3900.0 0 0 {name=l242 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 3900 0 0 {name=R81 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 3870.0 0 0 {name=l243 lab=n82}
C {devices/lab_pin.sym} 900.0 3930.0 0 0 {name=l244 lab=n81}
C {devices/lab_pin.sym} 880.0 3900.0 0 0 {name=l245 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 3900 0 0 {name=R82 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 3870.0 0 0 {name=l246 lab=n83}
C {devices/lab_pin.sym} 1200.0 3930.0 0 0 {name=l247 lab=n82}
C {devices/lab_pin.sym} 1180.0 3900.0 0 0 {name=l248 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 3900 0 0 {name=R83 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 3870.0 0 0 {name=l249 lab=n84}
C {devices/lab_pin.sym} 1500.0 3930.0 0 0 {name=l250 lab=n83}
C {devices/lab_pin.sym} 1480.0 3900.0 0 0 {name=l251 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 4200 0 0 {name=R84 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 4170.0 0 0 {name=l252 lab=n85}
C {devices/lab_pin.sym} 0.0 4230.0 0 0 {name=l253 lab=n84}
C {devices/lab_pin.sym} -20.0 4200.0 0 0 {name=l254 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 4200 0 0 {name=R85 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 4170.0 0 0 {name=l255 lab=n86}
C {devices/lab_pin.sym} 300.0 4230.0 0 0 {name=l256 lab=n85}
C {devices/lab_pin.sym} 280.0 4200.0 0 0 {name=l257 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 4200 0 0 {name=R86 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 4170.0 0 0 {name=l258 lab=n87}
C {devices/lab_pin.sym} 600.0 4230.0 0 0 {name=l259 lab=n86}
C {devices/lab_pin.sym} 580.0 4200.0 0 0 {name=l260 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 4200 0 0 {name=R87 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 4170.0 0 0 {name=l261 lab=n88}
C {devices/lab_pin.sym} 900.0 4230.0 0 0 {name=l262 lab=n87}
C {devices/lab_pin.sym} 880.0 4200.0 0 0 {name=l263 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 4200 0 0 {name=R88 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 4170.0 0 0 {name=l264 lab=n89}
C {devices/lab_pin.sym} 1200.0 4230.0 0 0 {name=l265 lab=n88}
C {devices/lab_pin.sym} 1180.0 4200.0 0 0 {name=l266 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 4200 0 0 {name=R89 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 4170.0 0 0 {name=l267 lab=n90}
C {devices/lab_pin.sym} 1500.0 4230.0 0 0 {name=l268 lab=n89}
C {devices/lab_pin.sym} 1480.0 4200.0 0 0 {name=l269 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 4500 0 0 {name=R90 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 4470.0 0 0 {name=l270 lab=n91}
C {devices/lab_pin.sym} 0.0 4530.0 0 0 {name=l271 lab=n90}
C {devices/lab_pin.sym} -20.0 4500.0 0 0 {name=l272 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 4500 0 0 {name=R91 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 4470.0 0 0 {name=l273 lab=n92}
C {devices/lab_pin.sym} 300.0 4530.0 0 0 {name=l274 lab=n91}
C {devices/lab_pin.sym} 280.0 4500.0 0 0 {name=l275 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 4500 0 0 {name=R92 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 4470.0 0 0 {name=l276 lab=n93}
C {devices/lab_pin.sym} 600.0 4530.0 0 0 {name=l277 lab=n92}
C {devices/lab_pin.sym} 580.0 4500.0 0 0 {name=l278 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 4500 0 0 {name=R93 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 4470.0 0 0 {name=l279 lab=n94}
C {devices/lab_pin.sym} 900.0 4530.0 0 0 {name=l280 lab=n93}
C {devices/lab_pin.sym} 880.0 4500.0 0 0 {name=l281 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 4500 0 0 {name=R94 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 4470.0 0 0 {name=l282 lab=n95}
C {devices/lab_pin.sym} 1200.0 4530.0 0 0 {name=l283 lab=n94}
C {devices/lab_pin.sym} 1180.0 4500.0 0 0 {name=l284 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 4500 0 0 {name=R95 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 4470.0 0 0 {name=l285 lab=n96}
C {devices/lab_pin.sym} 1500.0 4530.0 0 0 {name=l286 lab=n95}
C {devices/lab_pin.sym} 1480.0 4500.0 0 0 {name=l287 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 4800 0 0 {name=R96 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 4770.0 0 0 {name=l288 lab=n97}
C {devices/lab_pin.sym} 0.0 4830.0 0 0 {name=l289 lab=n96}
C {devices/lab_pin.sym} -20.0 4800.0 0 0 {name=l290 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 4800 0 0 {name=R97 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 4770.0 0 0 {name=l291 lab=n98}
C {devices/lab_pin.sym} 300.0 4830.0 0 0 {name=l292 lab=n97}
C {devices/lab_pin.sym} 280.0 4800.0 0 0 {name=l293 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 4800 0 0 {name=R98 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 4770.0 0 0 {name=l294 lab=n99}
C {devices/lab_pin.sym} 600.0 4830.0 0 0 {name=l295 lab=n98}
C {devices/lab_pin.sym} 580.0 4800.0 0 0 {name=l296 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 4800 0 0 {name=R99 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 4770.0 0 0 {name=l297 lab=n100}
C {devices/lab_pin.sym} 900.0 4830.0 0 0 {name=l298 lab=n99}
C {devices/lab_pin.sym} 880.0 4800.0 0 0 {name=l299 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 4800 0 0 {name=R100 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 4770.0 0 0 {name=l300 lab=n101}
C {devices/lab_pin.sym} 1200.0 4830.0 0 0 {name=l301 lab=n100}
C {devices/lab_pin.sym} 1180.0 4800.0 0 0 {name=l302 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 4800 0 0 {name=R101 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 4770.0 0 0 {name=l303 lab=n102}
C {devices/lab_pin.sym} 1500.0 4830.0 0 0 {name=l304 lab=n101}
C {devices/lab_pin.sym} 1480.0 4800.0 0 0 {name=l305 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 5100 0 0 {name=R102 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 5070.0 0 0 {name=l306 lab=n103}
C {devices/lab_pin.sym} 0.0 5130.0 0 0 {name=l307 lab=n102}
C {devices/lab_pin.sym} -20.0 5100.0 0 0 {name=l308 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 5100 0 0 {name=R103 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 5070.0 0 0 {name=l309 lab=n104}
C {devices/lab_pin.sym} 300.0 5130.0 0 0 {name=l310 lab=n103}
C {devices/lab_pin.sym} 280.0 5100.0 0 0 {name=l311 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 5100 0 0 {name=R104 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 5070.0 0 0 {name=l312 lab=n105}
C {devices/lab_pin.sym} 600.0 5130.0 0 0 {name=l313 lab=n104}
C {devices/lab_pin.sym} 580.0 5100.0 0 0 {name=l314 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 5100 0 0 {name=R105 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 5070.0 0 0 {name=l315 lab=n106}
C {devices/lab_pin.sym} 900.0 5130.0 0 0 {name=l316 lab=n105}
C {devices/lab_pin.sym} 880.0 5100.0 0 0 {name=l317 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 5100 0 0 {name=R106 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 5070.0 0 0 {name=l318 lab=n107}
C {devices/lab_pin.sym} 1200.0 5130.0 0 0 {name=l319 lab=n106}
C {devices/lab_pin.sym} 1180.0 5100.0 0 0 {name=l320 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 5100 0 0 {name=R107 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 5070.0 0 0 {name=l321 lab=n108}
C {devices/lab_pin.sym} 1500.0 5130.0 0 0 {name=l322 lab=n107}
C {devices/lab_pin.sym} 1480.0 5100.0 0 0 {name=l323 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 5400 0 0 {name=R108 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 5370.0 0 0 {name=l324 lab=n109}
C {devices/lab_pin.sym} 0.0 5430.0 0 0 {name=l325 lab=n108}
C {devices/lab_pin.sym} -20.0 5400.0 0 0 {name=l326 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 5400 0 0 {name=R109 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 5370.0 0 0 {name=l327 lab=n110}
C {devices/lab_pin.sym} 300.0 5430.0 0 0 {name=l328 lab=n109}
C {devices/lab_pin.sym} 280.0 5400.0 0 0 {name=l329 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 5400 0 0 {name=R110 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 5370.0 0 0 {name=l330 lab=n111}
C {devices/lab_pin.sym} 600.0 5430.0 0 0 {name=l331 lab=n110}
C {devices/lab_pin.sym} 580.0 5400.0 0 0 {name=l332 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 5400 0 0 {name=R111 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 5370.0 0 0 {name=l333 lab=n112}
C {devices/lab_pin.sym} 900.0 5430.0 0 0 {name=l334 lab=n111}
C {devices/lab_pin.sym} 880.0 5400.0 0 0 {name=l335 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 5400 0 0 {name=R112 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 5370.0 0 0 {name=l336 lab=n113}
C {devices/lab_pin.sym} 1200.0 5430.0 0 0 {name=l337 lab=n112}
C {devices/lab_pin.sym} 1180.0 5400.0 0 0 {name=l338 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 5400 0 0 {name=R113 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 5370.0 0 0 {name=l339 lab=n114}
C {devices/lab_pin.sym} 1500.0 5430.0 0 0 {name=l340 lab=n113}
C {devices/lab_pin.sym} 1480.0 5400.0 0 0 {name=l341 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 5700 0 0 {name=R114 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 5670.0 0 0 {name=l342 lab=n115}
C {devices/lab_pin.sym} 0.0 5730.0 0 0 {name=l343 lab=n114}
C {devices/lab_pin.sym} -20.0 5700.0 0 0 {name=l344 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 5700 0 0 {name=R115 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 5670.0 0 0 {name=l345 lab=n116}
C {devices/lab_pin.sym} 300.0 5730.0 0 0 {name=l346 lab=n115}
C {devices/lab_pin.sym} 280.0 5700.0 0 0 {name=l347 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 5700 0 0 {name=R116 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 5670.0 0 0 {name=l348 lab=n117}
C {devices/lab_pin.sym} 600.0 5730.0 0 0 {name=l349 lab=n116}
C {devices/lab_pin.sym} 580.0 5700.0 0 0 {name=l350 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 5700 0 0 {name=R117 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 5670.0 0 0 {name=l351 lab=n118}
C {devices/lab_pin.sym} 900.0 5730.0 0 0 {name=l352 lab=n117}
C {devices/lab_pin.sym} 880.0 5700.0 0 0 {name=l353 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 5700 0 0 {name=R118 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 5670.0 0 0 {name=l354 lab=n119}
C {devices/lab_pin.sym} 1200.0 5730.0 0 0 {name=l355 lab=n118}
C {devices/lab_pin.sym} 1180.0 5700.0 0 0 {name=l356 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 5700 0 0 {name=R119 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 5670.0 0 0 {name=l357 lab=n120}
C {devices/lab_pin.sym} 1500.0 5730.0 0 0 {name=l358 lab=n119}
C {devices/lab_pin.sym} 1480.0 5700.0 0 0 {name=l359 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 6000 0 0 {name=R120 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 5970.0 0 0 {name=l360 lab=n121}
C {devices/lab_pin.sym} 0.0 6030.0 0 0 {name=l361 lab=n120}
C {devices/lab_pin.sym} -20.0 6000.0 0 0 {name=l362 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 6000 0 0 {name=R121 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 5970.0 0 0 {name=l363 lab=n122}
C {devices/lab_pin.sym} 300.0 6030.0 0 0 {name=l364 lab=n121}
C {devices/lab_pin.sym} 280.0 6000.0 0 0 {name=l365 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 6000 0 0 {name=R122 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 5970.0 0 0 {name=l366 lab=n123}
C {devices/lab_pin.sym} 600.0 6030.0 0 0 {name=l367 lab=n122}
C {devices/lab_pin.sym} 580.0 6000.0 0 0 {name=l368 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 6000 0 0 {name=R123 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 5970.0 0 0 {name=l369 lab=n124}
C {devices/lab_pin.sym} 900.0 6030.0 0 0 {name=l370 lab=n123}
C {devices/lab_pin.sym} 880.0 6000.0 0 0 {name=l371 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 6000 0 0 {name=R124 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 5970.0 0 0 {name=l372 lab=n125}
C {devices/lab_pin.sym} 1200.0 6030.0 0 0 {name=l373 lab=n124}
C {devices/lab_pin.sym} 1180.0 6000.0 0 0 {name=l374 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 6000 0 0 {name=R125 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 5970.0 0 0 {name=l375 lab=n126}
C {devices/lab_pin.sym} 1500.0 6030.0 0 0 {name=l376 lab=n125}
C {devices/lab_pin.sym} 1480.0 6000.0 0 0 {name=l377 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 6300 0 0 {name=R126 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 6270.0 0 0 {name=l378 lab=n127}
C {devices/lab_pin.sym} 0.0 6330.0 0 0 {name=l379 lab=n126}
C {devices/lab_pin.sym} -20.0 6300.0 0 0 {name=l380 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 6300 0 0 {name=R127 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 6270.0 0 0 {name=l381 lab=n128}
C {devices/lab_pin.sym} 300.0 6330.0 0 0 {name=l382 lab=n127}
C {devices/lab_pin.sym} 280.0 6300.0 0 0 {name=l383 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 6300 0 0 {name=R128 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 6270.0 0 0 {name=l384 lab=n129}
C {devices/lab_pin.sym} 600.0 6330.0 0 0 {name=l385 lab=n128}
C {devices/lab_pin.sym} 580.0 6300.0 0 0 {name=l386 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 6300 0 0 {name=R129 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 6270.0 0 0 {name=l387 lab=n130}
C {devices/lab_pin.sym} 900.0 6330.0 0 0 {name=l388 lab=n129}
C {devices/lab_pin.sym} 880.0 6300.0 0 0 {name=l389 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 6300 0 0 {name=R130 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 6270.0 0 0 {name=l390 lab=n131}
C {devices/lab_pin.sym} 1200.0 6330.0 0 0 {name=l391 lab=n130}
C {devices/lab_pin.sym} 1180.0 6300.0 0 0 {name=l392 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 6300 0 0 {name=R131 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 6270.0 0 0 {name=l393 lab=n132}
C {devices/lab_pin.sym} 1500.0 6330.0 0 0 {name=l394 lab=n131}
C {devices/lab_pin.sym} 1480.0 6300.0 0 0 {name=l395 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 6600 0 0 {name=R132 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 6570.0 0 0 {name=l396 lab=n133}
C {devices/lab_pin.sym} 0.0 6630.0 0 0 {name=l397 lab=n132}
C {devices/lab_pin.sym} -20.0 6600.0 0 0 {name=l398 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 6600 0 0 {name=R133 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 6570.0 0 0 {name=l399 lab=n134}
C {devices/lab_pin.sym} 300.0 6630.0 0 0 {name=l400 lab=n133}
C {devices/lab_pin.sym} 280.0 6600.0 0 0 {name=l401 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 6600 0 0 {name=R134 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 6570.0 0 0 {name=l402 lab=n135}
C {devices/lab_pin.sym} 600.0 6630.0 0 0 {name=l403 lab=n134}
C {devices/lab_pin.sym} 580.0 6600.0 0 0 {name=l404 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 6600 0 0 {name=R135 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 6570.0 0 0 {name=l405 lab=n136}
C {devices/lab_pin.sym} 900.0 6630.0 0 0 {name=l406 lab=n135}
C {devices/lab_pin.sym} 880.0 6600.0 0 0 {name=l407 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 6600 0 0 {name=R136 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 6570.0 0 0 {name=l408 lab=n137}
C {devices/lab_pin.sym} 1200.0 6630.0 0 0 {name=l409 lab=n136}
C {devices/lab_pin.sym} 1180.0 6600.0 0 0 {name=l410 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 6600 0 0 {name=R137 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 6570.0 0 0 {name=l411 lab=n138}
C {devices/lab_pin.sym} 1500.0 6630.0 0 0 {name=l412 lab=n137}
C {devices/lab_pin.sym} 1480.0 6600.0 0 0 {name=l413 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 6900 0 0 {name=R138 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 6870.0 0 0 {name=l414 lab=n139}
C {devices/lab_pin.sym} 0.0 6930.0 0 0 {name=l415 lab=n138}
C {devices/lab_pin.sym} -20.0 6900.0 0 0 {name=l416 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 6900 0 0 {name=R139 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 6870.0 0 0 {name=l417 lab=n140}
C {devices/lab_pin.sym} 300.0 6930.0 0 0 {name=l418 lab=n139}
C {devices/lab_pin.sym} 280.0 6900.0 0 0 {name=l419 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 6900 0 0 {name=R140 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 6870.0 0 0 {name=l420 lab=n141}
C {devices/lab_pin.sym} 600.0 6930.0 0 0 {name=l421 lab=n140}
C {devices/lab_pin.sym} 580.0 6900.0 0 0 {name=l422 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 6900 0 0 {name=R141 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 6870.0 0 0 {name=l423 lab=n142}
C {devices/lab_pin.sym} 900.0 6930.0 0 0 {name=l424 lab=n141}
C {devices/lab_pin.sym} 880.0 6900.0 0 0 {name=l425 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 6900 0 0 {name=R142 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 6870.0 0 0 {name=l426 lab=n143}
C {devices/lab_pin.sym} 1200.0 6930.0 0 0 {name=l427 lab=n142}
C {devices/lab_pin.sym} 1180.0 6900.0 0 0 {name=l428 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 6900 0 0 {name=R143 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 6870.0 0 0 {name=l429 lab=n144}
C {devices/lab_pin.sym} 1500.0 6930.0 0 0 {name=l430 lab=n143}
C {devices/lab_pin.sym} 1480.0 6900.0 0 0 {name=l431 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 7200 0 0 {name=R144 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 7170.0 0 0 {name=l432 lab=n145}
C {devices/lab_pin.sym} 0.0 7230.0 0 0 {name=l433 lab=n144}
C {devices/lab_pin.sym} -20.0 7200.0 0 0 {name=l434 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 7200 0 0 {name=R145 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 7170.0 0 0 {name=l435 lab=n146}
C {devices/lab_pin.sym} 300.0 7230.0 0 0 {name=l436 lab=n145}
C {devices/lab_pin.sym} 280.0 7200.0 0 0 {name=l437 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 7200 0 0 {name=R146 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 7170.0 0 0 {name=l438 lab=n147}
C {devices/lab_pin.sym} 600.0 7230.0 0 0 {name=l439 lab=n146}
C {devices/lab_pin.sym} 580.0 7200.0 0 0 {name=l440 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 7200 0 0 {name=R147 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 7170.0 0 0 {name=l441 lab=n148}
C {devices/lab_pin.sym} 900.0 7230.0 0 0 {name=l442 lab=n147}
C {devices/lab_pin.sym} 880.0 7200.0 0 0 {name=l443 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 7200 0 0 {name=R148 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 7170.0 0 0 {name=l444 lab=n149}
C {devices/lab_pin.sym} 1200.0 7230.0 0 0 {name=l445 lab=n148}
C {devices/lab_pin.sym} 1180.0 7200.0 0 0 {name=l446 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 7200 0 0 {name=R149 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 7170.0 0 0 {name=l447 lab=n150}
C {devices/lab_pin.sym} 1500.0 7230.0 0 0 {name=l448 lab=n149}
C {devices/lab_pin.sym} 1480.0 7200.0 0 0 {name=l449 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 7500 0 0 {name=R150 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 7470.0 0 0 {name=l450 lab=n151}
C {devices/lab_pin.sym} 0.0 7530.0 0 0 {name=l451 lab=n150}
C {devices/lab_pin.sym} -20.0 7500.0 0 0 {name=l452 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 7500 0 0 {name=R151 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 7470.0 0 0 {name=l453 lab=n152}
C {devices/lab_pin.sym} 300.0 7530.0 0 0 {name=l454 lab=n151}
C {devices/lab_pin.sym} 280.0 7500.0 0 0 {name=l455 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 7500 0 0 {name=R152 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 7470.0 0 0 {name=l456 lab=n153}
C {devices/lab_pin.sym} 600.0 7530.0 0 0 {name=l457 lab=n152}
C {devices/lab_pin.sym} 580.0 7500.0 0 0 {name=l458 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 7500 0 0 {name=R153 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 7470.0 0 0 {name=l459 lab=n154}
C {devices/lab_pin.sym} 900.0 7530.0 0 0 {name=l460 lab=n153}
C {devices/lab_pin.sym} 880.0 7500.0 0 0 {name=l461 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 7500 0 0 {name=R154 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 7470.0 0 0 {name=l462 lab=n155}
C {devices/lab_pin.sym} 1200.0 7530.0 0 0 {name=l463 lab=n154}
C {devices/lab_pin.sym} 1180.0 7500.0 0 0 {name=l464 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 7500 0 0 {name=R155 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 7470.0 0 0 {name=l465 lab=n156}
C {devices/lab_pin.sym} 1500.0 7530.0 0 0 {name=l466 lab=n155}
C {devices/lab_pin.sym} 1480.0 7500.0 0 0 {name=l467 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 7800 0 0 {name=R156 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 7770.0 0 0 {name=l468 lab=n157}
C {devices/lab_pin.sym} 0.0 7830.0 0 0 {name=l469 lab=n156}
C {devices/lab_pin.sym} -20.0 7800.0 0 0 {name=l470 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 7800 0 0 {name=R157 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 7770.0 0 0 {name=l471 lab=n158}
C {devices/lab_pin.sym} 300.0 7830.0 0 0 {name=l472 lab=n157}
C {devices/lab_pin.sym} 280.0 7800.0 0 0 {name=l473 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 7800 0 0 {name=R158 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 7770.0 0 0 {name=l474 lab=n159}
C {devices/lab_pin.sym} 600.0 7830.0 0 0 {name=l475 lab=n158}
C {devices/lab_pin.sym} 580.0 7800.0 0 0 {name=l476 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 7800 0 0 {name=R159 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 7770.0 0 0 {name=l477 lab=n160}
C {devices/lab_pin.sym} 900.0 7830.0 0 0 {name=l478 lab=n159}
C {devices/lab_pin.sym} 880.0 7800.0 0 0 {name=l479 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 7800 0 0 {name=R160 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 7770.0 0 0 {name=l480 lab=n161}
C {devices/lab_pin.sym} 1200.0 7830.0 0 0 {name=l481 lab=n160}
C {devices/lab_pin.sym} 1180.0 7800.0 0 0 {name=l482 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 7800 0 0 {name=R161 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 7770.0 0 0 {name=l483 lab=n162}
C {devices/lab_pin.sym} 1500.0 7830.0 0 0 {name=l484 lab=n161}
C {devices/lab_pin.sym} 1480.0 7800.0 0 0 {name=l485 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 8100 0 0 {name=R162 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 8070.0 0 0 {name=l486 lab=n163}
C {devices/lab_pin.sym} 0.0 8130.0 0 0 {name=l487 lab=n162}
C {devices/lab_pin.sym} -20.0 8100.0 0 0 {name=l488 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 8100 0 0 {name=R163 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 8070.0 0 0 {name=l489 lab=n164}
C {devices/lab_pin.sym} 300.0 8130.0 0 0 {name=l490 lab=n163}
C {devices/lab_pin.sym} 280.0 8100.0 0 0 {name=l491 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 8100 0 0 {name=R164 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 8070.0 0 0 {name=l492 lab=n165}
C {devices/lab_pin.sym} 600.0 8130.0 0 0 {name=l493 lab=n164}
C {devices/lab_pin.sym} 580.0 8100.0 0 0 {name=l494 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 8100 0 0 {name=R165 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 8070.0 0 0 {name=l495 lab=n166}
C {devices/lab_pin.sym} 900.0 8130.0 0 0 {name=l496 lab=n165}
C {devices/lab_pin.sym} 880.0 8100.0 0 0 {name=l497 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 8100 0 0 {name=R166 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 8070.0 0 0 {name=l498 lab=n167}
C {devices/lab_pin.sym} 1200.0 8130.0 0 0 {name=l499 lab=n166}
C {devices/lab_pin.sym} 1180.0 8100.0 0 0 {name=l500 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 8100 0 0 {name=R167 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 8070.0 0 0 {name=l501 lab=n168}
C {devices/lab_pin.sym} 1500.0 8130.0 0 0 {name=l502 lab=n167}
C {devices/lab_pin.sym} 1480.0 8100.0 0 0 {name=l503 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 8400 0 0 {name=R168 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 8370.0 0 0 {name=l504 lab=n169}
C {devices/lab_pin.sym} 0.0 8430.0 0 0 {name=l505 lab=n168}
C {devices/lab_pin.sym} -20.0 8400.0 0 0 {name=l506 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 8400 0 0 {name=R169 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 8370.0 0 0 {name=l507 lab=n170}
C {devices/lab_pin.sym} 300.0 8430.0 0 0 {name=l508 lab=n169}
C {devices/lab_pin.sym} 280.0 8400.0 0 0 {name=l509 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 8400 0 0 {name=R170 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 8370.0 0 0 {name=l510 lab=n171}
C {devices/lab_pin.sym} 600.0 8430.0 0 0 {name=l511 lab=n170}
C {devices/lab_pin.sym} 580.0 8400.0 0 0 {name=l512 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 8400 0 0 {name=R171 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 8370.0 0 0 {name=l513 lab=n172}
C {devices/lab_pin.sym} 900.0 8430.0 0 0 {name=l514 lab=n171}
C {devices/lab_pin.sym} 880.0 8400.0 0 0 {name=l515 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 8400 0 0 {name=R172 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 8370.0 0 0 {name=l516 lab=n173}
C {devices/lab_pin.sym} 1200.0 8430.0 0 0 {name=l517 lab=n172}
C {devices/lab_pin.sym} 1180.0 8400.0 0 0 {name=l518 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 8400 0 0 {name=R173 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 8370.0 0 0 {name=l519 lab=n174}
C {devices/lab_pin.sym} 1500.0 8430.0 0 0 {name=l520 lab=n173}
C {devices/lab_pin.sym} 1480.0 8400.0 0 0 {name=l521 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 8700 0 0 {name=R174 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 8670.0 0 0 {name=l522 lab=n175}
C {devices/lab_pin.sym} 0.0 8730.0 0 0 {name=l523 lab=n174}
C {devices/lab_pin.sym} -20.0 8700.0 0 0 {name=l524 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 8700 0 0 {name=R175 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 8670.0 0 0 {name=l525 lab=n176}
C {devices/lab_pin.sym} 300.0 8730.0 0 0 {name=l526 lab=n175}
C {devices/lab_pin.sym} 280.0 8700.0 0 0 {name=l527 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 8700 0 0 {name=R176 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 8670.0 0 0 {name=l528 lab=n177}
C {devices/lab_pin.sym} 600.0 8730.0 0 0 {name=l529 lab=n176}
C {devices/lab_pin.sym} 580.0 8700.0 0 0 {name=l530 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 8700 0 0 {name=R177 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 8670.0 0 0 {name=l531 lab=n178}
C {devices/lab_pin.sym} 900.0 8730.0 0 0 {name=l532 lab=n177}
C {devices/lab_pin.sym} 880.0 8700.0 0 0 {name=l533 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 8700 0 0 {name=R178 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 8670.0 0 0 {name=l534 lab=n179}
C {devices/lab_pin.sym} 1200.0 8730.0 0 0 {name=l535 lab=n178}
C {devices/lab_pin.sym} 1180.0 8700.0 0 0 {name=l536 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 8700 0 0 {name=R179 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 8670.0 0 0 {name=l537 lab=n180}
C {devices/lab_pin.sym} 1500.0 8730.0 0 0 {name=l538 lab=n179}
C {devices/lab_pin.sym} 1480.0 8700.0 0 0 {name=l539 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 9000 0 0 {name=R180 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 8970.0 0 0 {name=l540 lab=n181}
C {devices/lab_pin.sym} 0.0 9030.0 0 0 {name=l541 lab=n180}
C {devices/lab_pin.sym} -20.0 9000.0 0 0 {name=l542 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 9000 0 0 {name=R181 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 8970.0 0 0 {name=l543 lab=n182}
C {devices/lab_pin.sym} 300.0 9030.0 0 0 {name=l544 lab=n181}
C {devices/lab_pin.sym} 280.0 9000.0 0 0 {name=l545 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 9000 0 0 {name=R182 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 8970.0 0 0 {name=l546 lab=n183}
C {devices/lab_pin.sym} 600.0 9030.0 0 0 {name=l547 lab=n182}
C {devices/lab_pin.sym} 580.0 9000.0 0 0 {name=l548 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 9000 0 0 {name=R183 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 8970.0 0 0 {name=l549 lab=n184}
C {devices/lab_pin.sym} 900.0 9030.0 0 0 {name=l550 lab=n183}
C {devices/lab_pin.sym} 880.0 9000.0 0 0 {name=l551 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 9000 0 0 {name=R184 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 8970.0 0 0 {name=l552 lab=n185}
C {devices/lab_pin.sym} 1200.0 9030.0 0 0 {name=l553 lab=n184}
C {devices/lab_pin.sym} 1180.0 9000.0 0 0 {name=l554 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 9000 0 0 {name=R185 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 8970.0 0 0 {name=l555 lab=n186}
C {devices/lab_pin.sym} 1500.0 9030.0 0 0 {name=l556 lab=n185}
C {devices/lab_pin.sym} 1480.0 9000.0 0 0 {name=l557 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 9300 0 0 {name=R186 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 9270.0 0 0 {name=l558 lab=n187}
C {devices/lab_pin.sym} 0.0 9330.0 0 0 {name=l559 lab=n186}
C {devices/lab_pin.sym} -20.0 9300.0 0 0 {name=l560 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 9300 0 0 {name=R187 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 9270.0 0 0 {name=l561 lab=n188}
C {devices/lab_pin.sym} 300.0 9330.0 0 0 {name=l562 lab=n187}
C {devices/lab_pin.sym} 280.0 9300.0 0 0 {name=l563 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 9300 0 0 {name=R188 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 9270.0 0 0 {name=l564 lab=n189}
C {devices/lab_pin.sym} 600.0 9330.0 0 0 {name=l565 lab=n188}
C {devices/lab_pin.sym} 580.0 9300.0 0 0 {name=l566 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 9300 0 0 {name=R189 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 9270.0 0 0 {name=l567 lab=n190}
C {devices/lab_pin.sym} 900.0 9330.0 0 0 {name=l568 lab=n189}
C {devices/lab_pin.sym} 880.0 9300.0 0 0 {name=l569 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 9300 0 0 {name=R190 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 9270.0 0 0 {name=l570 lab=n191}
C {devices/lab_pin.sym} 1200.0 9330.0 0 0 {name=l571 lab=n190}
C {devices/lab_pin.sym} 1180.0 9300.0 0 0 {name=l572 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 9300 0 0 {name=R191 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 9270.0 0 0 {name=l573 lab=n192}
C {devices/lab_pin.sym} 1500.0 9330.0 0 0 {name=l574 lab=n191}
C {devices/lab_pin.sym} 1480.0 9300.0 0 0 {name=l575 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 9600 0 0 {name=R192 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 9570.0 0 0 {name=l576 lab=n193}
C {devices/lab_pin.sym} 0.0 9630.0 0 0 {name=l577 lab=n192}
C {devices/lab_pin.sym} -20.0 9600.0 0 0 {name=l578 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 9600 0 0 {name=R193 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 9570.0 0 0 {name=l579 lab=n194}
C {devices/lab_pin.sym} 300.0 9630.0 0 0 {name=l580 lab=n193}
C {devices/lab_pin.sym} 280.0 9600.0 0 0 {name=l581 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 9600 0 0 {name=R194 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 9570.0 0 0 {name=l582 lab=n195}
C {devices/lab_pin.sym} 600.0 9630.0 0 0 {name=l583 lab=n194}
C {devices/lab_pin.sym} 580.0 9600.0 0 0 {name=l584 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 9600 0 0 {name=R195 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 9570.0 0 0 {name=l585 lab=n196}
C {devices/lab_pin.sym} 900.0 9630.0 0 0 {name=l586 lab=n195}
C {devices/lab_pin.sym} 880.0 9600.0 0 0 {name=l587 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 9600 0 0 {name=R196 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 9570.0 0 0 {name=l588 lab=n197}
C {devices/lab_pin.sym} 1200.0 9630.0 0 0 {name=l589 lab=n196}
C {devices/lab_pin.sym} 1180.0 9600.0 0 0 {name=l590 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 9600 0 0 {name=R197 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 9570.0 0 0 {name=l591 lab=n198}
C {devices/lab_pin.sym} 1500.0 9630.0 0 0 {name=l592 lab=n197}
C {devices/lab_pin.sym} 1480.0 9600.0 0 0 {name=l593 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 9900 0 0 {name=R198 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 9870.0 0 0 {name=l594 lab=n199}
C {devices/lab_pin.sym} 0.0 9930.0 0 0 {name=l595 lab=n198}
C {devices/lab_pin.sym} -20.0 9900.0 0 0 {name=l596 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 9900 0 0 {name=R199 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 9870.0 0 0 {name=l597 lab=n200}
C {devices/lab_pin.sym} 300.0 9930.0 0 0 {name=l598 lab=n199}
C {devices/lab_pin.sym} 280.0 9900.0 0 0 {name=l599 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 9900 0 0 {name=R200 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 9870.0 0 0 {name=l600 lab=n201}
C {devices/lab_pin.sym} 600.0 9930.0 0 0 {name=l601 lab=n200}
C {devices/lab_pin.sym} 580.0 9900.0 0 0 {name=l602 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 9900 0 0 {name=R201 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 9870.0 0 0 {name=l603 lab=n202}
C {devices/lab_pin.sym} 900.0 9930.0 0 0 {name=l604 lab=n201}
C {devices/lab_pin.sym} 880.0 9900.0 0 0 {name=l605 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 9900 0 0 {name=R202 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 9870.0 0 0 {name=l606 lab=n203}
C {devices/lab_pin.sym} 1200.0 9930.0 0 0 {name=l607 lab=n202}
C {devices/lab_pin.sym} 1180.0 9900.0 0 0 {name=l608 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 9900 0 0 {name=R203 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 9870.0 0 0 {name=l609 lab=n204}
C {devices/lab_pin.sym} 1500.0 9930.0 0 0 {name=l610 lab=n203}
C {devices/lab_pin.sym} 1480.0 9900.0 0 0 {name=l611 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 10200 0 0 {name=R204 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 10170.0 0 0 {name=l612 lab=n205}
C {devices/lab_pin.sym} 0.0 10230.0 0 0 {name=l613 lab=n204}
C {devices/lab_pin.sym} -20.0 10200.0 0 0 {name=l614 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 10200 0 0 {name=R205 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 10170.0 0 0 {name=l615 lab=n206}
C {devices/lab_pin.sym} 300.0 10230.0 0 0 {name=l616 lab=n205}
C {devices/lab_pin.sym} 280.0 10200.0 0 0 {name=l617 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 10200 0 0 {name=R206 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 10170.0 0 0 {name=l618 lab=n207}
C {devices/lab_pin.sym} 600.0 10230.0 0 0 {name=l619 lab=n206}
C {devices/lab_pin.sym} 580.0 10200.0 0 0 {name=l620 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 10200 0 0 {name=R207 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 10170.0 0 0 {name=l621 lab=n208}
C {devices/lab_pin.sym} 900.0 10230.0 0 0 {name=l622 lab=n207}
C {devices/lab_pin.sym} 880.0 10200.0 0 0 {name=l623 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 10200 0 0 {name=R208 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 10170.0 0 0 {name=l624 lab=n209}
C {devices/lab_pin.sym} 1200.0 10230.0 0 0 {name=l625 lab=n208}
C {devices/lab_pin.sym} 1180.0 10200.0 0 0 {name=l626 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 10200 0 0 {name=R209 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 10170.0 0 0 {name=l627 lab=n210}
C {devices/lab_pin.sym} 1500.0 10230.0 0 0 {name=l628 lab=n209}
C {devices/lab_pin.sym} 1480.0 10200.0 0 0 {name=l629 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 10500 0 0 {name=R210 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 10470.0 0 0 {name=l630 lab=n211}
C {devices/lab_pin.sym} 0.0 10530.0 0 0 {name=l631 lab=n210}
C {devices/lab_pin.sym} -20.0 10500.0 0 0 {name=l632 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 10500 0 0 {name=R211 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 10470.0 0 0 {name=l633 lab=n212}
C {devices/lab_pin.sym} 300.0 10530.0 0 0 {name=l634 lab=n211}
C {devices/lab_pin.sym} 280.0 10500.0 0 0 {name=l635 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 10500 0 0 {name=R212 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 10470.0 0 0 {name=l636 lab=n213}
C {devices/lab_pin.sym} 600.0 10530.0 0 0 {name=l637 lab=n212}
C {devices/lab_pin.sym} 580.0 10500.0 0 0 {name=l638 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 10500 0 0 {name=R213 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 10470.0 0 0 {name=l639 lab=n214}
C {devices/lab_pin.sym} 900.0 10530.0 0 0 {name=l640 lab=n213}
C {devices/lab_pin.sym} 880.0 10500.0 0 0 {name=l641 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 10500 0 0 {name=R214 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 10470.0 0 0 {name=l642 lab=n215}
C {devices/lab_pin.sym} 1200.0 10530.0 0 0 {name=l643 lab=n214}
C {devices/lab_pin.sym} 1180.0 10500.0 0 0 {name=l644 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 10500 0 0 {name=R215 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 10470.0 0 0 {name=l645 lab=n216}
C {devices/lab_pin.sym} 1500.0 10530.0 0 0 {name=l646 lab=n215}
C {devices/lab_pin.sym} 1480.0 10500.0 0 0 {name=l647 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 10800 0 0 {name=R216 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 10770.0 0 0 {name=l648 lab=n217}
C {devices/lab_pin.sym} 0.0 10830.0 0 0 {name=l649 lab=n216}
C {devices/lab_pin.sym} -20.0 10800.0 0 0 {name=l650 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 10800 0 0 {name=R217 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 10770.0 0 0 {name=l651 lab=n218}
C {devices/lab_pin.sym} 300.0 10830.0 0 0 {name=l652 lab=n217}
C {devices/lab_pin.sym} 280.0 10800.0 0 0 {name=l653 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 10800 0 0 {name=R218 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 10770.0 0 0 {name=l654 lab=n219}
C {devices/lab_pin.sym} 600.0 10830.0 0 0 {name=l655 lab=n218}
C {devices/lab_pin.sym} 580.0 10800.0 0 0 {name=l656 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 10800 0 0 {name=R219 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 10770.0 0 0 {name=l657 lab=n220}
C {devices/lab_pin.sym} 900.0 10830.0 0 0 {name=l658 lab=n219}
C {devices/lab_pin.sym} 880.0 10800.0 0 0 {name=l659 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 10800 0 0 {name=R220 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 10770.0 0 0 {name=l660 lab=n221}
C {devices/lab_pin.sym} 1200.0 10830.0 0 0 {name=l661 lab=n220}
C {devices/lab_pin.sym} 1180.0 10800.0 0 0 {name=l662 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 10800 0 0 {name=R221 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 10770.0 0 0 {name=l663 lab=n222}
C {devices/lab_pin.sym} 1500.0 10830.0 0 0 {name=l664 lab=n221}
C {devices/lab_pin.sym} 1480.0 10800.0 0 0 {name=l665 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 11100 0 0 {name=R222 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 11070.0 0 0 {name=l666 lab=n223}
C {devices/lab_pin.sym} 0.0 11130.0 0 0 {name=l667 lab=n222}
C {devices/lab_pin.sym} -20.0 11100.0 0 0 {name=l668 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 11100 0 0 {name=R223 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 11070.0 0 0 {name=l669 lab=n224}
C {devices/lab_pin.sym} 300.0 11130.0 0 0 {name=l670 lab=n223}
C {devices/lab_pin.sym} 280.0 11100.0 0 0 {name=l671 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 11100 0 0 {name=R224 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 11070.0 0 0 {name=l672 lab=n225}
C {devices/lab_pin.sym} 600.0 11130.0 0 0 {name=l673 lab=n224}
C {devices/lab_pin.sym} 580.0 11100.0 0 0 {name=l674 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 11100 0 0 {name=R225 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 11070.0 0 0 {name=l675 lab=n226}
C {devices/lab_pin.sym} 900.0 11130.0 0 0 {name=l676 lab=n225}
C {devices/lab_pin.sym} 880.0 11100.0 0 0 {name=l677 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 11100 0 0 {name=R226 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 11070.0 0 0 {name=l678 lab=n227}
C {devices/lab_pin.sym} 1200.0 11130.0 0 0 {name=l679 lab=n226}
C {devices/lab_pin.sym} 1180.0 11100.0 0 0 {name=l680 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 11100 0 0 {name=R227 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 11070.0 0 0 {name=l681 lab=n228}
C {devices/lab_pin.sym} 1500.0 11130.0 0 0 {name=l682 lab=n227}
C {devices/lab_pin.sym} 1480.0 11100.0 0 0 {name=l683 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 11400 0 0 {name=R228 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 11370.0 0 0 {name=l684 lab=n229}
C {devices/lab_pin.sym} 0.0 11430.0 0 0 {name=l685 lab=n228}
C {devices/lab_pin.sym} -20.0 11400.0 0 0 {name=l686 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 11400 0 0 {name=R229 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 11370.0 0 0 {name=l687 lab=n230}
C {devices/lab_pin.sym} 300.0 11430.0 0 0 {name=l688 lab=n229}
C {devices/lab_pin.sym} 280.0 11400.0 0 0 {name=l689 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 11400 0 0 {name=R230 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 11370.0 0 0 {name=l690 lab=n231}
C {devices/lab_pin.sym} 600.0 11430.0 0 0 {name=l691 lab=n230}
C {devices/lab_pin.sym} 580.0 11400.0 0 0 {name=l692 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 11400 0 0 {name=R231 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 11370.0 0 0 {name=l693 lab=n232}
C {devices/lab_pin.sym} 900.0 11430.0 0 0 {name=l694 lab=n231}
C {devices/lab_pin.sym} 880.0 11400.0 0 0 {name=l695 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 11400 0 0 {name=R232 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 11370.0 0 0 {name=l696 lab=n233}
C {devices/lab_pin.sym} 1200.0 11430.0 0 0 {name=l697 lab=n232}
C {devices/lab_pin.sym} 1180.0 11400.0 0 0 {name=l698 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 11400 0 0 {name=R233 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 11370.0 0 0 {name=l699 lab=n234}
C {devices/lab_pin.sym} 1500.0 11430.0 0 0 {name=l700 lab=n233}
C {devices/lab_pin.sym} 1480.0 11400.0 0 0 {name=l701 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 11700 0 0 {name=R234 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 11670.0 0 0 {name=l702 lab=n235}
C {devices/lab_pin.sym} 0.0 11730.0 0 0 {name=l703 lab=n234}
C {devices/lab_pin.sym} -20.0 11700.0 0 0 {name=l704 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 11700 0 0 {name=R235 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 11670.0 0 0 {name=l705 lab=n236}
C {devices/lab_pin.sym} 300.0 11730.0 0 0 {name=l706 lab=n235}
C {devices/lab_pin.sym} 280.0 11700.0 0 0 {name=l707 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 11700 0 0 {name=R236 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 11670.0 0 0 {name=l708 lab=n237}
C {devices/lab_pin.sym} 600.0 11730.0 0 0 {name=l709 lab=n236}
C {devices/lab_pin.sym} 580.0 11700.0 0 0 {name=l710 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 11700 0 0 {name=R237 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 11670.0 0 0 {name=l711 lab=n238}
C {devices/lab_pin.sym} 900.0 11730.0 0 0 {name=l712 lab=n237}
C {devices/lab_pin.sym} 880.0 11700.0 0 0 {name=l713 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 11700 0 0 {name=R238 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 11670.0 0 0 {name=l714 lab=n239}
C {devices/lab_pin.sym} 1200.0 11730.0 0 0 {name=l715 lab=n238}
C {devices/lab_pin.sym} 1180.0 11700.0 0 0 {name=l716 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 11700 0 0 {name=R239 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 11670.0 0 0 {name=l717 lab=n240}
C {devices/lab_pin.sym} 1500.0 11730.0 0 0 {name=l718 lab=n239}
C {devices/lab_pin.sym} 1480.0 11700.0 0 0 {name=l719 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 12000 0 0 {name=R240 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 11970.0 0 0 {name=l720 lab=n241}
C {devices/lab_pin.sym} 0.0 12030.0 0 0 {name=l721 lab=n240}
C {devices/lab_pin.sym} -20.0 12000.0 0 0 {name=l722 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 12000 0 0 {name=R241 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 11970.0 0 0 {name=l723 lab=n242}
C {devices/lab_pin.sym} 300.0 12030.0 0 0 {name=l724 lab=n241}
C {devices/lab_pin.sym} 280.0 12000.0 0 0 {name=l725 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 12000 0 0 {name=R242 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 11970.0 0 0 {name=l726 lab=n243}
C {devices/lab_pin.sym} 600.0 12030.0 0 0 {name=l727 lab=n242}
C {devices/lab_pin.sym} 580.0 12000.0 0 0 {name=l728 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 12000 0 0 {name=R243 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 11970.0 0 0 {name=l729 lab=n244}
C {devices/lab_pin.sym} 900.0 12030.0 0 0 {name=l730 lab=n243}
C {devices/lab_pin.sym} 880.0 12000.0 0 0 {name=l731 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 12000 0 0 {name=R244 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 11970.0 0 0 {name=l732 lab=n245}
C {devices/lab_pin.sym} 1200.0 12030.0 0 0 {name=l733 lab=n244}
C {devices/lab_pin.sym} 1180.0 12000.0 0 0 {name=l734 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 12000 0 0 {name=R245 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 11970.0 0 0 {name=l735 lab=n246}
C {devices/lab_pin.sym} 1500.0 12030.0 0 0 {name=l736 lab=n245}
C {devices/lab_pin.sym} 1480.0 12000.0 0 0 {name=l737 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 12300 0 0 {name=R246 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 12270.0 0 0 {name=l738 lab=n247}
C {devices/lab_pin.sym} 0.0 12330.0 0 0 {name=l739 lab=n246}
C {devices/lab_pin.sym} -20.0 12300.0 0 0 {name=l740 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 12300 0 0 {name=R247 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 12270.0 0 0 {name=l741 lab=n248}
C {devices/lab_pin.sym} 300.0 12330.0 0 0 {name=l742 lab=n247}
C {devices/lab_pin.sym} 280.0 12300.0 0 0 {name=l743 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 12300 0 0 {name=R248 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 12270.0 0 0 {name=l744 lab=n249}
C {devices/lab_pin.sym} 600.0 12330.0 0 0 {name=l745 lab=n248}
C {devices/lab_pin.sym} 580.0 12300.0 0 0 {name=l746 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 12300 0 0 {name=R249 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 12270.0 0 0 {name=l747 lab=n250}
C {devices/lab_pin.sym} 900.0 12330.0 0 0 {name=l748 lab=n249}
C {devices/lab_pin.sym} 880.0 12300.0 0 0 {name=l749 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 12300 0 0 {name=R250 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 12270.0 0 0 {name=l750 lab=n251}
C {devices/lab_pin.sym} 1200.0 12330.0 0 0 {name=l751 lab=n250}
C {devices/lab_pin.sym} 1180.0 12300.0 0 0 {name=l752 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 12300 0 0 {name=R251 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 12270.0 0 0 {name=l753 lab=n252}
C {devices/lab_pin.sym} 1500.0 12330.0 0 0 {name=l754 lab=n251}
C {devices/lab_pin.sym} 1480.0 12300.0 0 0 {name=l755 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 12600 0 0 {name=R252 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 12570.0 0 0 {name=l756 lab=n253}
C {devices/lab_pin.sym} 0.0 12630.0 0 0 {name=l757 lab=n252}
C {devices/lab_pin.sym} -20.0 12600.0 0 0 {name=l758 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 12600 0 0 {name=R253 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 12570.0 0 0 {name=l759 lab=n254}
C {devices/lab_pin.sym} 300.0 12630.0 0 0 {name=l760 lab=n253}
C {devices/lab_pin.sym} 280.0 12600.0 0 0 {name=l761 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 12600 0 0 {name=R254 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 12570.0 0 0 {name=l762 lab=n255}
C {devices/lab_pin.sym} 600.0 12630.0 0 0 {name=l763 lab=n254}
C {devices/lab_pin.sym} 580.0 12600.0 0 0 {name=l764 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 12600 0 0 {name=R255 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 12570.0 0 0 {name=l765 lab=n256}
C {devices/lab_pin.sym} 900.0 12630.0 0 0 {name=l766 lab=n255}
C {devices/lab_pin.sym} 880.0 12600.0 0 0 {name=l767 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 12600 0 0 {name=R256 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 12570.0 0 0 {name=l768 lab=n257}
C {devices/lab_pin.sym} 1200.0 12630.0 0 0 {name=l769 lab=n256}
C {devices/lab_pin.sym} 1180.0 12600.0 0 0 {name=l770 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 12600 0 0 {name=R257 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 12570.0 0 0 {name=l771 lab=n258}
C {devices/lab_pin.sym} 1500.0 12630.0 0 0 {name=l772 lab=n257}
C {devices/lab_pin.sym} 1480.0 12600.0 0 0 {name=l773 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 12900 0 0 {name=R258 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 12870.0 0 0 {name=l774 lab=n259}
C {devices/lab_pin.sym} 0.0 12930.0 0 0 {name=l775 lab=n258}
C {devices/lab_pin.sym} -20.0 12900.0 0 0 {name=l776 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 12900 0 0 {name=R259 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 12870.0 0 0 {name=l777 lab=n260}
C {devices/lab_pin.sym} 300.0 12930.0 0 0 {name=l778 lab=n259}
C {devices/lab_pin.sym} 280.0 12900.0 0 0 {name=l779 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 12900 0 0 {name=R260 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 12870.0 0 0 {name=l780 lab=n261}
C {devices/lab_pin.sym} 600.0 12930.0 0 0 {name=l781 lab=n260}
C {devices/lab_pin.sym} 580.0 12900.0 0 0 {name=l782 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 12900 0 0 {name=R261 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 12870.0 0 0 {name=l783 lab=n262}
C {devices/lab_pin.sym} 900.0 12930.0 0 0 {name=l784 lab=n261}
C {devices/lab_pin.sym} 880.0 12900.0 0 0 {name=l785 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 12900 0 0 {name=R262 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 12870.0 0 0 {name=l786 lab=n263}
C {devices/lab_pin.sym} 1200.0 12930.0 0 0 {name=l787 lab=n262}
C {devices/lab_pin.sym} 1180.0 12900.0 0 0 {name=l788 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 12900 0 0 {name=R263 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 12870.0 0 0 {name=l789 lab=n264}
C {devices/lab_pin.sym} 1500.0 12930.0 0 0 {name=l790 lab=n263}
C {devices/lab_pin.sym} 1480.0 12900.0 0 0 {name=l791 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 13200 0 0 {name=R264 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 13170.0 0 0 {name=l792 lab=n265}
C {devices/lab_pin.sym} 0.0 13230.0 0 0 {name=l793 lab=n264}
C {devices/lab_pin.sym} -20.0 13200.0 0 0 {name=l794 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 13200 0 0 {name=R265 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 13170.0 0 0 {name=l795 lab=n266}
C {devices/lab_pin.sym} 300.0 13230.0 0 0 {name=l796 lab=n265}
C {devices/lab_pin.sym} 280.0 13200.0 0 0 {name=l797 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 13200 0 0 {name=R266 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 13170.0 0 0 {name=l798 lab=n267}
C {devices/lab_pin.sym} 600.0 13230.0 0 0 {name=l799 lab=n266}
C {devices/lab_pin.sym} 580.0 13200.0 0 0 {name=l800 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 13200 0 0 {name=R267 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 13170.0 0 0 {name=l801 lab=n268}
C {devices/lab_pin.sym} 900.0 13230.0 0 0 {name=l802 lab=n267}
C {devices/lab_pin.sym} 880.0 13200.0 0 0 {name=l803 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 13200 0 0 {name=R268 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 13170.0 0 0 {name=l804 lab=n269}
C {devices/lab_pin.sym} 1200.0 13230.0 0 0 {name=l805 lab=n268}
C {devices/lab_pin.sym} 1180.0 13200.0 0 0 {name=l806 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 13200 0 0 {name=R269 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 13170.0 0 0 {name=l807 lab=n270}
C {devices/lab_pin.sym} 1500.0 13230.0 0 0 {name=l808 lab=n269}
C {devices/lab_pin.sym} 1480.0 13200.0 0 0 {name=l809 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 13500 0 0 {name=R270 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 13470.0 0 0 {name=l810 lab=n271}
C {devices/lab_pin.sym} 0.0 13530.0 0 0 {name=l811 lab=n270}
C {devices/lab_pin.sym} -20.0 13500.0 0 0 {name=l812 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 13500 0 0 {name=R271 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 13470.0 0 0 {name=l813 lab=n272}
C {devices/lab_pin.sym} 300.0 13530.0 0 0 {name=l814 lab=n271}
C {devices/lab_pin.sym} 280.0 13500.0 0 0 {name=l815 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 13500 0 0 {name=R272 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 13470.0 0 0 {name=l816 lab=n273}
C {devices/lab_pin.sym} 600.0 13530.0 0 0 {name=l817 lab=n272}
C {devices/lab_pin.sym} 580.0 13500.0 0 0 {name=l818 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 13500 0 0 {name=R273 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 13470.0 0 0 {name=l819 lab=n274}
C {devices/lab_pin.sym} 900.0 13530.0 0 0 {name=l820 lab=n273}
C {devices/lab_pin.sym} 880.0 13500.0 0 0 {name=l821 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 13500 0 0 {name=R274 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 13470.0 0 0 {name=l822 lab=n275}
C {devices/lab_pin.sym} 1200.0 13530.0 0 0 {name=l823 lab=n274}
C {devices/lab_pin.sym} 1180.0 13500.0 0 0 {name=l824 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 13500 0 0 {name=R275 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 13470.0 0 0 {name=l825 lab=n276}
C {devices/lab_pin.sym} 1500.0 13530.0 0 0 {name=l826 lab=n275}
C {devices/lab_pin.sym} 1480.0 13500.0 0 0 {name=l827 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 13800 0 0 {name=R276 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 13770.0 0 0 {name=l828 lab=n277}
C {devices/lab_pin.sym} 0.0 13830.0 0 0 {name=l829 lab=n276}
C {devices/lab_pin.sym} -20.0 13800.0 0 0 {name=l830 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 13800 0 0 {name=R277 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 13770.0 0 0 {name=l831 lab=n278}
C {devices/lab_pin.sym} 300.0 13830.0 0 0 {name=l832 lab=n277}
C {devices/lab_pin.sym} 280.0 13800.0 0 0 {name=l833 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 13800 0 0 {name=R278 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 13770.0 0 0 {name=l834 lab=n279}
C {devices/lab_pin.sym} 600.0 13830.0 0 0 {name=l835 lab=n278}
C {devices/lab_pin.sym} 580.0 13800.0 0 0 {name=l836 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 13800 0 0 {name=R279 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 13770.0 0 0 {name=l837 lab=n280}
C {devices/lab_pin.sym} 900.0 13830.0 0 0 {name=l838 lab=n279}
C {devices/lab_pin.sym} 880.0 13800.0 0 0 {name=l839 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 13800 0 0 {name=R280 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 13770.0 0 0 {name=l840 lab=n281}
C {devices/lab_pin.sym} 1200.0 13830.0 0 0 {name=l841 lab=n280}
C {devices/lab_pin.sym} 1180.0 13800.0 0 0 {name=l842 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 13800 0 0 {name=R281 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 13770.0 0 0 {name=l843 lab=n282}
C {devices/lab_pin.sym} 1500.0 13830.0 0 0 {name=l844 lab=n281}
C {devices/lab_pin.sym} 1480.0 13800.0 0 0 {name=l845 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 14100 0 0 {name=R282 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 14070.0 0 0 {name=l846 lab=n283}
C {devices/lab_pin.sym} 0.0 14130.0 0 0 {name=l847 lab=n282}
C {devices/lab_pin.sym} -20.0 14100.0 0 0 {name=l848 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 14100 0 0 {name=R283 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 14070.0 0 0 {name=l849 lab=n284}
C {devices/lab_pin.sym} 300.0 14130.0 0 0 {name=l850 lab=n283}
C {devices/lab_pin.sym} 280.0 14100.0 0 0 {name=l851 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 14100 0 0 {name=R284 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 14070.0 0 0 {name=l852 lab=n285}
C {devices/lab_pin.sym} 600.0 14130.0 0 0 {name=l853 lab=n284}
C {devices/lab_pin.sym} 580.0 14100.0 0 0 {name=l854 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 14100 0 0 {name=R285 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 14070.0 0 0 {name=l855 lab=n286}
C {devices/lab_pin.sym} 900.0 14130.0 0 0 {name=l856 lab=n285}
C {devices/lab_pin.sym} 880.0 14100.0 0 0 {name=l857 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 14100 0 0 {name=R286 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 14070.0 0 0 {name=l858 lab=n287}
C {devices/lab_pin.sym} 1200.0 14130.0 0 0 {name=l859 lab=n286}
C {devices/lab_pin.sym} 1180.0 14100.0 0 0 {name=l860 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 14100 0 0 {name=R287 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 14070.0 0 0 {name=l861 lab=n288}
C {devices/lab_pin.sym} 1500.0 14130.0 0 0 {name=l862 lab=n287}
C {devices/lab_pin.sym} 1480.0 14100.0 0 0 {name=l863 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 14400 0 0 {name=R288 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 14370.0 0 0 {name=l864 lab=n289}
C {devices/lab_pin.sym} 0.0 14430.0 0 0 {name=l865 lab=n288}
C {devices/lab_pin.sym} -20.0 14400.0 0 0 {name=l866 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 14400 0 0 {name=R289 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 14370.0 0 0 {name=l867 lab=n290}
C {devices/lab_pin.sym} 300.0 14430.0 0 0 {name=l868 lab=n289}
C {devices/lab_pin.sym} 280.0 14400.0 0 0 {name=l869 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 14400 0 0 {name=R290 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 14370.0 0 0 {name=l870 lab=n291}
C {devices/lab_pin.sym} 600.0 14430.0 0 0 {name=l871 lab=n290}
C {devices/lab_pin.sym} 580.0 14400.0 0 0 {name=l872 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 14400 0 0 {name=R291 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 14370.0 0 0 {name=l873 lab=n292}
C {devices/lab_pin.sym} 900.0 14430.0 0 0 {name=l874 lab=n291}
C {devices/lab_pin.sym} 880.0 14400.0 0 0 {name=l875 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 14400 0 0 {name=R292 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 14370.0 0 0 {name=l876 lab=n293}
C {devices/lab_pin.sym} 1200.0 14430.0 0 0 {name=l877 lab=n292}
C {devices/lab_pin.sym} 1180.0 14400.0 0 0 {name=l878 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 14400 0 0 {name=R293 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 14370.0 0 0 {name=l879 lab=n294}
C {devices/lab_pin.sym} 1500.0 14430.0 0 0 {name=l880 lab=n293}
C {devices/lab_pin.sym} 1480.0 14400.0 0 0 {name=l881 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 14700 0 0 {name=R294 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 14670.0 0 0 {name=l882 lab=n295}
C {devices/lab_pin.sym} 0.0 14730.0 0 0 {name=l883 lab=n294}
C {devices/lab_pin.sym} -20.0 14700.0 0 0 {name=l884 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 14700 0 0 {name=R295 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 14670.0 0 0 {name=l885 lab=n296}
C {devices/lab_pin.sym} 300.0 14730.0 0 0 {name=l886 lab=n295}
C {devices/lab_pin.sym} 280.0 14700.0 0 0 {name=l887 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 14700 0 0 {name=R296 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 14670.0 0 0 {name=l888 lab=n297}
C {devices/lab_pin.sym} 600.0 14730.0 0 0 {name=l889 lab=n296}
C {devices/lab_pin.sym} 580.0 14700.0 0 0 {name=l890 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 14700 0 0 {name=R297 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 14670.0 0 0 {name=l891 lab=n298}
C {devices/lab_pin.sym} 900.0 14730.0 0 0 {name=l892 lab=n297}
C {devices/lab_pin.sym} 880.0 14700.0 0 0 {name=l893 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 14700 0 0 {name=R298 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 14670.0 0 0 {name=l894 lab=n299}
C {devices/lab_pin.sym} 1200.0 14730.0 0 0 {name=l895 lab=n298}
C {devices/lab_pin.sym} 1180.0 14700.0 0 0 {name=l896 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 14700 0 0 {name=R299 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 14670.0 0 0 {name=l897 lab=n300}
C {devices/lab_pin.sym} 1500.0 14730.0 0 0 {name=l898 lab=n299}
C {devices/lab_pin.sym} 1480.0 14700.0 0 0 {name=l899 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 15000 0 0 {name=R300 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 14970.0 0 0 {name=l900 lab=n301}
C {devices/lab_pin.sym} 0.0 15030.0 0 0 {name=l901 lab=n300}
C {devices/lab_pin.sym} -20.0 15000.0 0 0 {name=l902 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 15000 0 0 {name=R301 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 14970.0 0 0 {name=l903 lab=n302}
C {devices/lab_pin.sym} 300.0 15030.0 0 0 {name=l904 lab=n301}
C {devices/lab_pin.sym} 280.0 15000.0 0 0 {name=l905 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 15000 0 0 {name=R302 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 14970.0 0 0 {name=l906 lab=n303}
C {devices/lab_pin.sym} 600.0 15030.0 0 0 {name=l907 lab=n302}
C {devices/lab_pin.sym} 580.0 15000.0 0 0 {name=l908 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 15000 0 0 {name=R303 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 14970.0 0 0 {name=l909 lab=n304}
C {devices/lab_pin.sym} 900.0 15030.0 0 0 {name=l910 lab=n303}
C {devices/lab_pin.sym} 880.0 15000.0 0 0 {name=l911 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 15000 0 0 {name=R304 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 14970.0 0 0 {name=l912 lab=n305}
C {devices/lab_pin.sym} 1200.0 15030.0 0 0 {name=l913 lab=n304}
C {devices/lab_pin.sym} 1180.0 15000.0 0 0 {name=l914 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 15000 0 0 {name=R305 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 14970.0 0 0 {name=l915 lab=n306}
C {devices/lab_pin.sym} 1500.0 15030.0 0 0 {name=l916 lab=n305}
C {devices/lab_pin.sym} 1480.0 15000.0 0 0 {name=l917 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 15300 0 0 {name=R306 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 15270.0 0 0 {name=l918 lab=n307}
C {devices/lab_pin.sym} 0.0 15330.0 0 0 {name=l919 lab=n306}
C {devices/lab_pin.sym} -20.0 15300.0 0 0 {name=l920 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 15300 0 0 {name=R307 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 15270.0 0 0 {name=l921 lab=n308}
C {devices/lab_pin.sym} 300.0 15330.0 0 0 {name=l922 lab=n307}
C {devices/lab_pin.sym} 280.0 15300.0 0 0 {name=l923 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 15300 0 0 {name=R308 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 15270.0 0 0 {name=l924 lab=n309}
C {devices/lab_pin.sym} 600.0 15330.0 0 0 {name=l925 lab=n308}
C {devices/lab_pin.sym} 580.0 15300.0 0 0 {name=l926 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 15300 0 0 {name=R309 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 15270.0 0 0 {name=l927 lab=n310}
C {devices/lab_pin.sym} 900.0 15330.0 0 0 {name=l928 lab=n309}
C {devices/lab_pin.sym} 880.0 15300.0 0 0 {name=l929 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 15300 0 0 {name=R310 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 15270.0 0 0 {name=l930 lab=n311}
C {devices/lab_pin.sym} 1200.0 15330.0 0 0 {name=l931 lab=n310}
C {devices/lab_pin.sym} 1180.0 15300.0 0 0 {name=l932 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 15300 0 0 {name=R311 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 15270.0 0 0 {name=l933 lab=n312}
C {devices/lab_pin.sym} 1500.0 15330.0 0 0 {name=l934 lab=n311}
C {devices/lab_pin.sym} 1480.0 15300.0 0 0 {name=l935 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 15600 0 0 {name=R312 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 15570.0 0 0 {name=l936 lab=n313}
C {devices/lab_pin.sym} 0.0 15630.0 0 0 {name=l937 lab=n312}
C {devices/lab_pin.sym} -20.0 15600.0 0 0 {name=l938 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 15600 0 0 {name=R313 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 15570.0 0 0 {name=l939 lab=n314}
C {devices/lab_pin.sym} 300.0 15630.0 0 0 {name=l940 lab=n313}
C {devices/lab_pin.sym} 280.0 15600.0 0 0 {name=l941 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 15600 0 0 {name=R314 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 15570.0 0 0 {name=l942 lab=n315}
C {devices/lab_pin.sym} 600.0 15630.0 0 0 {name=l943 lab=n314}
C {devices/lab_pin.sym} 580.0 15600.0 0 0 {name=l944 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 15600 0 0 {name=R315 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 15570.0 0 0 {name=l945 lab=n316}
C {devices/lab_pin.sym} 900.0 15630.0 0 0 {name=l946 lab=n315}
C {devices/lab_pin.sym} 880.0 15600.0 0 0 {name=l947 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 15600 0 0 {name=R316 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 15570.0 0 0 {name=l948 lab=n317}
C {devices/lab_pin.sym} 1200.0 15630.0 0 0 {name=l949 lab=n316}
C {devices/lab_pin.sym} 1180.0 15600.0 0 0 {name=l950 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 15600 0 0 {name=R317 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 15570.0 0 0 {name=l951 lab=n318}
C {devices/lab_pin.sym} 1500.0 15630.0 0 0 {name=l952 lab=n317}
C {devices/lab_pin.sym} 1480.0 15600.0 0 0 {name=l953 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 15900 0 0 {name=R318 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 15870.0 0 0 {name=l954 lab=n319}
C {devices/lab_pin.sym} 0.0 15930.0 0 0 {name=l955 lab=n318}
C {devices/lab_pin.sym} -20.0 15900.0 0 0 {name=l956 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 15900 0 0 {name=R319 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 15870.0 0 0 {name=l957 lab=n320}
C {devices/lab_pin.sym} 300.0 15930.0 0 0 {name=l958 lab=n319}
C {devices/lab_pin.sym} 280.0 15900.0 0 0 {name=l959 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 15900 0 0 {name=R320 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 15870.0 0 0 {name=l960 lab=n321}
C {devices/lab_pin.sym} 600.0 15930.0 0 0 {name=l961 lab=n320}
C {devices/lab_pin.sym} 580.0 15900.0 0 0 {name=l962 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 15900 0 0 {name=R321 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 15870.0 0 0 {name=l963 lab=n322}
C {devices/lab_pin.sym} 900.0 15930.0 0 0 {name=l964 lab=n321}
C {devices/lab_pin.sym} 880.0 15900.0 0 0 {name=l965 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 15900 0 0 {name=R322 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 15870.0 0 0 {name=l966 lab=n323}
C {devices/lab_pin.sym} 1200.0 15930.0 0 0 {name=l967 lab=n322}
C {devices/lab_pin.sym} 1180.0 15900.0 0 0 {name=l968 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 15900 0 0 {name=R323 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 15870.0 0 0 {name=l969 lab=n324}
C {devices/lab_pin.sym} 1500.0 15930.0 0 0 {name=l970 lab=n323}
C {devices/lab_pin.sym} 1480.0 15900.0 0 0 {name=l971 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 16200 0 0 {name=R324 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 16170.0 0 0 {name=l972 lab=n325}
C {devices/lab_pin.sym} 0.0 16230.0 0 0 {name=l973 lab=n324}
C {devices/lab_pin.sym} -20.0 16200.0 0 0 {name=l974 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 16200 0 0 {name=R325 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 16170.0 0 0 {name=l975 lab=n326}
C {devices/lab_pin.sym} 300.0 16230.0 0 0 {name=l976 lab=n325}
C {devices/lab_pin.sym} 280.0 16200.0 0 0 {name=l977 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 16200 0 0 {name=R326 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 16170.0 0 0 {name=l978 lab=n327}
C {devices/lab_pin.sym} 600.0 16230.0 0 0 {name=l979 lab=n326}
C {devices/lab_pin.sym} 580.0 16200.0 0 0 {name=l980 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 16200 0 0 {name=R327 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 16170.0 0 0 {name=l981 lab=n328}
C {devices/lab_pin.sym} 900.0 16230.0 0 0 {name=l982 lab=n327}
C {devices/lab_pin.sym} 880.0 16200.0 0 0 {name=l983 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 16200 0 0 {name=R328 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 16170.0 0 0 {name=l984 lab=n329}
C {devices/lab_pin.sym} 1200.0 16230.0 0 0 {name=l985 lab=n328}
C {devices/lab_pin.sym} 1180.0 16200.0 0 0 {name=l986 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 16200 0 0 {name=R329 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 16170.0 0 0 {name=l987 lab=n330}
C {devices/lab_pin.sym} 1500.0 16230.0 0 0 {name=l988 lab=n329}
C {devices/lab_pin.sym} 1480.0 16200.0 0 0 {name=l989 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 16500 0 0 {name=R330 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 16470.0 0 0 {name=l990 lab=n331}
C {devices/lab_pin.sym} 0.0 16530.0 0 0 {name=l991 lab=n330}
C {devices/lab_pin.sym} -20.0 16500.0 0 0 {name=l992 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 16500 0 0 {name=R331 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 16470.0 0 0 {name=l993 lab=n332}
C {devices/lab_pin.sym} 300.0 16530.0 0 0 {name=l994 lab=n331}
C {devices/lab_pin.sym} 280.0 16500.0 0 0 {name=l995 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 16500 0 0 {name=R332 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 16470.0 0 0 {name=l996 lab=n333}
C {devices/lab_pin.sym} 600.0 16530.0 0 0 {name=l997 lab=n332}
C {devices/lab_pin.sym} 580.0 16500.0 0 0 {name=l998 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 16500 0 0 {name=R333 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 16470.0 0 0 {name=l999 lab=n334}
C {devices/lab_pin.sym} 900.0 16530.0 0 0 {name=l1000 lab=n333}
C {devices/lab_pin.sym} 880.0 16500.0 0 0 {name=l1001 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 16500 0 0 {name=R334 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 16470.0 0 0 {name=l1002 lab=n335}
C {devices/lab_pin.sym} 1200.0 16530.0 0 0 {name=l1003 lab=n334}
C {devices/lab_pin.sym} 1180.0 16500.0 0 0 {name=l1004 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 16500 0 0 {name=R335 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 16470.0 0 0 {name=l1005 lab=n336}
C {devices/lab_pin.sym} 1500.0 16530.0 0 0 {name=l1006 lab=n335}
C {devices/lab_pin.sym} 1480.0 16500.0 0 0 {name=l1007 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 16800 0 0 {name=R336 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 16770.0 0 0 {name=l1008 lab=n337}
C {devices/lab_pin.sym} 0.0 16830.0 0 0 {name=l1009 lab=n336}
C {devices/lab_pin.sym} -20.0 16800.0 0 0 {name=l1010 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 16800 0 0 {name=R337 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 16770.0 0 0 {name=l1011 lab=n338}
C {devices/lab_pin.sym} 300.0 16830.0 0 0 {name=l1012 lab=n337}
C {devices/lab_pin.sym} 280.0 16800.0 0 0 {name=l1013 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 16800 0 0 {name=R338 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 16770.0 0 0 {name=l1014 lab=n339}
C {devices/lab_pin.sym} 600.0 16830.0 0 0 {name=l1015 lab=n338}
C {devices/lab_pin.sym} 580.0 16800.0 0 0 {name=l1016 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 16800 0 0 {name=R339 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 16770.0 0 0 {name=l1017 lab=n340}
C {devices/lab_pin.sym} 900.0 16830.0 0 0 {name=l1018 lab=n339}
C {devices/lab_pin.sym} 880.0 16800.0 0 0 {name=l1019 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 16800 0 0 {name=R340 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 16770.0 0 0 {name=l1020 lab=n341}
C {devices/lab_pin.sym} 1200.0 16830.0 0 0 {name=l1021 lab=n340}
C {devices/lab_pin.sym} 1180.0 16800.0 0 0 {name=l1022 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 16800 0 0 {name=R341 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 16770.0 0 0 {name=l1023 lab=n342}
C {devices/lab_pin.sym} 1500.0 16830.0 0 0 {name=l1024 lab=n341}
C {devices/lab_pin.sym} 1480.0 16800.0 0 0 {name=l1025 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 17100 0 0 {name=R342 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 17070.0 0 0 {name=l1026 lab=n343}
C {devices/lab_pin.sym} 0.0 17130.0 0 0 {name=l1027 lab=n342}
C {devices/lab_pin.sym} -20.0 17100.0 0 0 {name=l1028 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 17100 0 0 {name=R343 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 17070.0 0 0 {name=l1029 lab=n344}
C {devices/lab_pin.sym} 300.0 17130.0 0 0 {name=l1030 lab=n343}
C {devices/lab_pin.sym} 280.0 17100.0 0 0 {name=l1031 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 17100 0 0 {name=R344 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 17070.0 0 0 {name=l1032 lab=n345}
C {devices/lab_pin.sym} 600.0 17130.0 0 0 {name=l1033 lab=n344}
C {devices/lab_pin.sym} 580.0 17100.0 0 0 {name=l1034 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 17100 0 0 {name=R345 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 17070.0 0 0 {name=l1035 lab=n346}
C {devices/lab_pin.sym} 900.0 17130.0 0 0 {name=l1036 lab=n345}
C {devices/lab_pin.sym} 880.0 17100.0 0 0 {name=l1037 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 17100 0 0 {name=R346 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 17070.0 0 0 {name=l1038 lab=n347}
C {devices/lab_pin.sym} 1200.0 17130.0 0 0 {name=l1039 lab=n346}
C {devices/lab_pin.sym} 1180.0 17100.0 0 0 {name=l1040 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 17100 0 0 {name=R347 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 17070.0 0 0 {name=l1041 lab=n348}
C {devices/lab_pin.sym} 1500.0 17130.0 0 0 {name=l1042 lab=n347}
C {devices/lab_pin.sym} 1480.0 17100.0 0 0 {name=l1043 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 17400 0 0 {name=R348 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 17370.0 0 0 {name=l1044 lab=n349}
C {devices/lab_pin.sym} 0.0 17430.0 0 0 {name=l1045 lab=n348}
C {devices/lab_pin.sym} -20.0 17400.0 0 0 {name=l1046 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 17400 0 0 {name=R349 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 17370.0 0 0 {name=l1047 lab=n350}
C {devices/lab_pin.sym} 300.0 17430.0 0 0 {name=l1048 lab=n349}
C {devices/lab_pin.sym} 280.0 17400.0 0 0 {name=l1049 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 17400 0 0 {name=R350 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 17370.0 0 0 {name=l1050 lab=n351}
C {devices/lab_pin.sym} 600.0 17430.0 0 0 {name=l1051 lab=n350}
C {devices/lab_pin.sym} 580.0 17400.0 0 0 {name=l1052 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 17400 0 0 {name=R351 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 17370.0 0 0 {name=l1053 lab=n352}
C {devices/lab_pin.sym} 900.0 17430.0 0 0 {name=l1054 lab=n351}
C {devices/lab_pin.sym} 880.0 17400.0 0 0 {name=l1055 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 17400 0 0 {name=R352 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 17370.0 0 0 {name=l1056 lab=n353}
C {devices/lab_pin.sym} 1200.0 17430.0 0 0 {name=l1057 lab=n352}
C {devices/lab_pin.sym} 1180.0 17400.0 0 0 {name=l1058 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 17400 0 0 {name=R353 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 17370.0 0 0 {name=l1059 lab=n354}
C {devices/lab_pin.sym} 1500.0 17430.0 0 0 {name=l1060 lab=n353}
C {devices/lab_pin.sym} 1480.0 17400.0 0 0 {name=l1061 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 17700 0 0 {name=R354 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 17670.0 0 0 {name=l1062 lab=n355}
C {devices/lab_pin.sym} 0.0 17730.0 0 0 {name=l1063 lab=n354}
C {devices/lab_pin.sym} -20.0 17700.0 0 0 {name=l1064 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 17700 0 0 {name=R355 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 17670.0 0 0 {name=l1065 lab=n356}
C {devices/lab_pin.sym} 300.0 17730.0 0 0 {name=l1066 lab=n355}
C {devices/lab_pin.sym} 280.0 17700.0 0 0 {name=l1067 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 17700 0 0 {name=R356 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 17670.0 0 0 {name=l1068 lab=n357}
C {devices/lab_pin.sym} 600.0 17730.0 0 0 {name=l1069 lab=n356}
C {devices/lab_pin.sym} 580.0 17700.0 0 0 {name=l1070 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 17700 0 0 {name=R357 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 17670.0 0 0 {name=l1071 lab=n358}
C {devices/lab_pin.sym} 900.0 17730.0 0 0 {name=l1072 lab=n357}
C {devices/lab_pin.sym} 880.0 17700.0 0 0 {name=l1073 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 17700 0 0 {name=R358 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 17670.0 0 0 {name=l1074 lab=n359}
C {devices/lab_pin.sym} 1200.0 17730.0 0 0 {name=l1075 lab=n358}
C {devices/lab_pin.sym} 1180.0 17700.0 0 0 {name=l1076 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 17700 0 0 {name=R359 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 17670.0 0 0 {name=l1077 lab=n360}
C {devices/lab_pin.sym} 1500.0 17730.0 0 0 {name=l1078 lab=n359}
C {devices/lab_pin.sym} 1480.0 17700.0 0 0 {name=l1079 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 18000 0 0 {name=R360 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 17970.0 0 0 {name=l1080 lab=n361}
C {devices/lab_pin.sym} 0.0 18030.0 0 0 {name=l1081 lab=n360}
C {devices/lab_pin.sym} -20.0 18000.0 0 0 {name=l1082 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 18000 0 0 {name=R361 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 17970.0 0 0 {name=l1083 lab=n362}
C {devices/lab_pin.sym} 300.0 18030.0 0 0 {name=l1084 lab=n361}
C {devices/lab_pin.sym} 280.0 18000.0 0 0 {name=l1085 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 18000 0 0 {name=R362 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 17970.0 0 0 {name=l1086 lab=n363}
C {devices/lab_pin.sym} 600.0 18030.0 0 0 {name=l1087 lab=n362}
C {devices/lab_pin.sym} 580.0 18000.0 0 0 {name=l1088 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 18000 0 0 {name=R363 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 17970.0 0 0 {name=l1089 lab=n364}
C {devices/lab_pin.sym} 900.0 18030.0 0 0 {name=l1090 lab=n363}
C {devices/lab_pin.sym} 880.0 18000.0 0 0 {name=l1091 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 18000 0 0 {name=R364 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 17970.0 0 0 {name=l1092 lab=n365}
C {devices/lab_pin.sym} 1200.0 18030.0 0 0 {name=l1093 lab=n364}
C {devices/lab_pin.sym} 1180.0 18000.0 0 0 {name=l1094 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 18000 0 0 {name=R365 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 17970.0 0 0 {name=l1095 lab=n366}
C {devices/lab_pin.sym} 1500.0 18030.0 0 0 {name=l1096 lab=n365}
C {devices/lab_pin.sym} 1480.0 18000.0 0 0 {name=l1097 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 18300 0 0 {name=R366 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 18270.0 0 0 {name=l1098 lab=n367}
C {devices/lab_pin.sym} 0.0 18330.0 0 0 {name=l1099 lab=n366}
C {devices/lab_pin.sym} -20.0 18300.0 0 0 {name=l1100 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 18300 0 0 {name=R367 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 18270.0 0 0 {name=l1101 lab=n368}
C {devices/lab_pin.sym} 300.0 18330.0 0 0 {name=l1102 lab=n367}
C {devices/lab_pin.sym} 280.0 18300.0 0 0 {name=l1103 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 18300 0 0 {name=R368 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 18270.0 0 0 {name=l1104 lab=n369}
C {devices/lab_pin.sym} 600.0 18330.0 0 0 {name=l1105 lab=n368}
C {devices/lab_pin.sym} 580.0 18300.0 0 0 {name=l1106 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 18300 0 0 {name=R369 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 18270.0 0 0 {name=l1107 lab=n370}
C {devices/lab_pin.sym} 900.0 18330.0 0 0 {name=l1108 lab=n369}
C {devices/lab_pin.sym} 880.0 18300.0 0 0 {name=l1109 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 18300 0 0 {name=R370 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 18270.0 0 0 {name=l1110 lab=n371}
C {devices/lab_pin.sym} 1200.0 18330.0 0 0 {name=l1111 lab=n370}
C {devices/lab_pin.sym} 1180.0 18300.0 0 0 {name=l1112 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 18300 0 0 {name=R371 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 18270.0 0 0 {name=l1113 lab=n372}
C {devices/lab_pin.sym} 1500.0 18330.0 0 0 {name=l1114 lab=n371}
C {devices/lab_pin.sym} 1480.0 18300.0 0 0 {name=l1115 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 18600 0 0 {name=R372 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 18570.0 0 0 {name=l1116 lab=n373}
C {devices/lab_pin.sym} 0.0 18630.0 0 0 {name=l1117 lab=n372}
C {devices/lab_pin.sym} -20.0 18600.0 0 0 {name=l1118 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 18600 0 0 {name=R373 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 18570.0 0 0 {name=l1119 lab=n374}
C {devices/lab_pin.sym} 300.0 18630.0 0 0 {name=l1120 lab=n373}
C {devices/lab_pin.sym} 280.0 18600.0 0 0 {name=l1121 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 18600 0 0 {name=R374 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 18570.0 0 0 {name=l1122 lab=n375}
C {devices/lab_pin.sym} 600.0 18630.0 0 0 {name=l1123 lab=n374}
C {devices/lab_pin.sym} 580.0 18600.0 0 0 {name=l1124 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 18600 0 0 {name=R375 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 18570.0 0 0 {name=l1125 lab=n376}
C {devices/lab_pin.sym} 900.0 18630.0 0 0 {name=l1126 lab=n375}
C {devices/lab_pin.sym} 880.0 18600.0 0 0 {name=l1127 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 18600 0 0 {name=R376 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 18570.0 0 0 {name=l1128 lab=n377}
C {devices/lab_pin.sym} 1200.0 18630.0 0 0 {name=l1129 lab=n376}
C {devices/lab_pin.sym} 1180.0 18600.0 0 0 {name=l1130 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 18600 0 0 {name=R377 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 18570.0 0 0 {name=l1131 lab=n378}
C {devices/lab_pin.sym} 1500.0 18630.0 0 0 {name=l1132 lab=n377}
C {devices/lab_pin.sym} 1480.0 18600.0 0 0 {name=l1133 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 18900 0 0 {name=R378 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 18870.0 0 0 {name=l1134 lab=n379}
C {devices/lab_pin.sym} 0.0 18930.0 0 0 {name=l1135 lab=n378}
C {devices/lab_pin.sym} -20.0 18900.0 0 0 {name=l1136 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 18900 0 0 {name=R379 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 18870.0 0 0 {name=l1137 lab=n380}
C {devices/lab_pin.sym} 300.0 18930.0 0 0 {name=l1138 lab=n379}
C {devices/lab_pin.sym} 280.0 18900.0 0 0 {name=l1139 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 18900 0 0 {name=R380 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 18870.0 0 0 {name=l1140 lab=n381}
C {devices/lab_pin.sym} 600.0 18930.0 0 0 {name=l1141 lab=n380}
C {devices/lab_pin.sym} 580.0 18900.0 0 0 {name=l1142 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 18900 0 0 {name=R381 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 18870.0 0 0 {name=l1143 lab=n382}
C {devices/lab_pin.sym} 900.0 18930.0 0 0 {name=l1144 lab=n381}
C {devices/lab_pin.sym} 880.0 18900.0 0 0 {name=l1145 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 18900 0 0 {name=R382 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 18870.0 0 0 {name=l1146 lab=n383}
C {devices/lab_pin.sym} 1200.0 18930.0 0 0 {name=l1147 lab=n382}
C {devices/lab_pin.sym} 1180.0 18900.0 0 0 {name=l1148 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 18900 0 0 {name=R383 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 18870.0 0 0 {name=l1149 lab=n384}
C {devices/lab_pin.sym} 1500.0 18930.0 0 0 {name=l1150 lab=n383}
C {devices/lab_pin.sym} 1480.0 18900.0 0 0 {name=l1151 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 19200 0 0 {name=R384 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 19170.0 0 0 {name=l1152 lab=n385}
C {devices/lab_pin.sym} 0.0 19230.0 0 0 {name=l1153 lab=n384}
C {devices/lab_pin.sym} -20.0 19200.0 0 0 {name=l1154 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 19200 0 0 {name=R385 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 19170.0 0 0 {name=l1155 lab=n386}
C {devices/lab_pin.sym} 300.0 19230.0 0 0 {name=l1156 lab=n385}
C {devices/lab_pin.sym} 280.0 19200.0 0 0 {name=l1157 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 19200 0 0 {name=R386 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 19170.0 0 0 {name=l1158 lab=n387}
C {devices/lab_pin.sym} 600.0 19230.0 0 0 {name=l1159 lab=n386}
C {devices/lab_pin.sym} 580.0 19200.0 0 0 {name=l1160 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 19200 0 0 {name=R387 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 19170.0 0 0 {name=l1161 lab=n388}
C {devices/lab_pin.sym} 900.0 19230.0 0 0 {name=l1162 lab=n387}
C {devices/lab_pin.sym} 880.0 19200.0 0 0 {name=l1163 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 19200 0 0 {name=R388 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 19170.0 0 0 {name=l1164 lab=n389}
C {devices/lab_pin.sym} 1200.0 19230.0 0 0 {name=l1165 lab=n388}
C {devices/lab_pin.sym} 1180.0 19200.0 0 0 {name=l1166 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 19200 0 0 {name=R389 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 19170.0 0 0 {name=l1167 lab=n390}
C {devices/lab_pin.sym} 1500.0 19230.0 0 0 {name=l1168 lab=n389}
C {devices/lab_pin.sym} 1480.0 19200.0 0 0 {name=l1169 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 19500 0 0 {name=R390 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 19470.0 0 0 {name=l1170 lab=n391}
C {devices/lab_pin.sym} 0.0 19530.0 0 0 {name=l1171 lab=n390}
C {devices/lab_pin.sym} -20.0 19500.0 0 0 {name=l1172 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 19500 0 0 {name=R391 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 19470.0 0 0 {name=l1173 lab=n392}
C {devices/lab_pin.sym} 300.0 19530.0 0 0 {name=l1174 lab=n391}
C {devices/lab_pin.sym} 280.0 19500.0 0 0 {name=l1175 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 19500 0 0 {name=R392 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 19470.0 0 0 {name=l1176 lab=n393}
C {devices/lab_pin.sym} 600.0 19530.0 0 0 {name=l1177 lab=n392}
C {devices/lab_pin.sym} 580.0 19500.0 0 0 {name=l1178 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 19500 0 0 {name=R393 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 19470.0 0 0 {name=l1179 lab=n394}
C {devices/lab_pin.sym} 900.0 19530.0 0 0 {name=l1180 lab=n393}
C {devices/lab_pin.sym} 880.0 19500.0 0 0 {name=l1181 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 19500 0 0 {name=R394 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 19470.0 0 0 {name=l1182 lab=n395}
C {devices/lab_pin.sym} 1200.0 19530.0 0 0 {name=l1183 lab=n394}
C {devices/lab_pin.sym} 1180.0 19500.0 0 0 {name=l1184 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 19500 0 0 {name=R395 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 19470.0 0 0 {name=l1185 lab=n396}
C {devices/lab_pin.sym} 1500.0 19530.0 0 0 {name=l1186 lab=n395}
C {devices/lab_pin.sym} 1480.0 19500.0 0 0 {name=l1187 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 19800 0 0 {name=R396 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 19770.0 0 0 {name=l1188 lab=n397}
C {devices/lab_pin.sym} 0.0 19830.0 0 0 {name=l1189 lab=n396}
C {devices/lab_pin.sym} -20.0 19800.0 0 0 {name=l1190 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 19800 0 0 {name=R397 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 19770.0 0 0 {name=l1191 lab=n398}
C {devices/lab_pin.sym} 300.0 19830.0 0 0 {name=l1192 lab=n397}
C {devices/lab_pin.sym} 280.0 19800.0 0 0 {name=l1193 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 19800 0 0 {name=R398 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 19770.0 0 0 {name=l1194 lab=n399}
C {devices/lab_pin.sym} 600.0 19830.0 0 0 {name=l1195 lab=n398}
C {devices/lab_pin.sym} 580.0 19800.0 0 0 {name=l1196 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 19800 0 0 {name=R399 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 19770.0 0 0 {name=l1197 lab=n400}
C {devices/lab_pin.sym} 900.0 19830.0 0 0 {name=l1198 lab=n399}
C {devices/lab_pin.sym} 880.0 19800.0 0 0 {name=l1199 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 19800 0 0 {name=R400 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 19770.0 0 0 {name=l1200 lab=n401}
C {devices/lab_pin.sym} 1200.0 19830.0 0 0 {name=l1201 lab=n400}
C {devices/lab_pin.sym} 1180.0 19800.0 0 0 {name=l1202 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 19800 0 0 {name=R401 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 19770.0 0 0 {name=l1203 lab=n402}
C {devices/lab_pin.sym} 1500.0 19830.0 0 0 {name=l1204 lab=n401}
C {devices/lab_pin.sym} 1480.0 19800.0 0 0 {name=l1205 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 20100 0 0 {name=R402 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 20070.0 0 0 {name=l1206 lab=n403}
C {devices/lab_pin.sym} 0.0 20130.0 0 0 {name=l1207 lab=n402}
C {devices/lab_pin.sym} -20.0 20100.0 0 0 {name=l1208 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 20100 0 0 {name=R403 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 20070.0 0 0 {name=l1209 lab=n404}
C {devices/lab_pin.sym} 300.0 20130.0 0 0 {name=l1210 lab=n403}
C {devices/lab_pin.sym} 280.0 20100.0 0 0 {name=l1211 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 20100 0 0 {name=R404 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 20070.0 0 0 {name=l1212 lab=n405}
C {devices/lab_pin.sym} 600.0 20130.0 0 0 {name=l1213 lab=n404}
C {devices/lab_pin.sym} 580.0 20100.0 0 0 {name=l1214 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 20100 0 0 {name=R405 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 20070.0 0 0 {name=l1215 lab=n406}
C {devices/lab_pin.sym} 900.0 20130.0 0 0 {name=l1216 lab=n405}
C {devices/lab_pin.sym} 880.0 20100.0 0 0 {name=l1217 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 20100 0 0 {name=R406 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 20070.0 0 0 {name=l1218 lab=n407}
C {devices/lab_pin.sym} 1200.0 20130.0 0 0 {name=l1219 lab=n406}
C {devices/lab_pin.sym} 1180.0 20100.0 0 0 {name=l1220 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 20100 0 0 {name=R407 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 20070.0 0 0 {name=l1221 lab=n408}
C {devices/lab_pin.sym} 1500.0 20130.0 0 0 {name=l1222 lab=n407}
C {devices/lab_pin.sym} 1480.0 20100.0 0 0 {name=l1223 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 20400 0 0 {name=R408 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 20370.0 0 0 {name=l1224 lab=n409}
C {devices/lab_pin.sym} 0.0 20430.0 0 0 {name=l1225 lab=n408}
C {devices/lab_pin.sym} -20.0 20400.0 0 0 {name=l1226 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 20400 0 0 {name=R409 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 20370.0 0 0 {name=l1227 lab=n410}
C {devices/lab_pin.sym} 300.0 20430.0 0 0 {name=l1228 lab=n409}
C {devices/lab_pin.sym} 280.0 20400.0 0 0 {name=l1229 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 20400 0 0 {name=R410 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 20370.0 0 0 {name=l1230 lab=n411}
C {devices/lab_pin.sym} 600.0 20430.0 0 0 {name=l1231 lab=n410}
C {devices/lab_pin.sym} 580.0 20400.0 0 0 {name=l1232 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 20400 0 0 {name=R411 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 20370.0 0 0 {name=l1233 lab=n412}
C {devices/lab_pin.sym} 900.0 20430.0 0 0 {name=l1234 lab=n411}
C {devices/lab_pin.sym} 880.0 20400.0 0 0 {name=l1235 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 20400 0 0 {name=R412 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 20370.0 0 0 {name=l1236 lab=n413}
C {devices/lab_pin.sym} 1200.0 20430.0 0 0 {name=l1237 lab=n412}
C {devices/lab_pin.sym} 1180.0 20400.0 0 0 {name=l1238 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 20400 0 0 {name=R413 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 20370.0 0 0 {name=l1239 lab=n414}
C {devices/lab_pin.sym} 1500.0 20430.0 0 0 {name=l1240 lab=n413}
C {devices/lab_pin.sym} 1480.0 20400.0 0 0 {name=l1241 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 20700 0 0 {name=R414 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 20670.0 0 0 {name=l1242 lab=n415}
C {devices/lab_pin.sym} 0.0 20730.0 0 0 {name=l1243 lab=n414}
C {devices/lab_pin.sym} -20.0 20700.0 0 0 {name=l1244 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 20700 0 0 {name=R415 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 20670.0 0 0 {name=l1245 lab=n416}
C {devices/lab_pin.sym} 300.0 20730.0 0 0 {name=l1246 lab=n415}
C {devices/lab_pin.sym} 280.0 20700.0 0 0 {name=l1247 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 20700 0 0 {name=R416 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 20670.0 0 0 {name=l1248 lab=n417}
C {devices/lab_pin.sym} 600.0 20730.0 0 0 {name=l1249 lab=n416}
C {devices/lab_pin.sym} 580.0 20700.0 0 0 {name=l1250 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 20700 0 0 {name=R417 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 20670.0 0 0 {name=l1251 lab=n418}
C {devices/lab_pin.sym} 900.0 20730.0 0 0 {name=l1252 lab=n417}
C {devices/lab_pin.sym} 880.0 20700.0 0 0 {name=l1253 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 20700 0 0 {name=R418 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 20670.0 0 0 {name=l1254 lab=n419}
C {devices/lab_pin.sym} 1200.0 20730.0 0 0 {name=l1255 lab=n418}
C {devices/lab_pin.sym} 1180.0 20700.0 0 0 {name=l1256 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 20700 0 0 {name=R419 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 20670.0 0 0 {name=l1257 lab=n420}
C {devices/lab_pin.sym} 1500.0 20730.0 0 0 {name=l1258 lab=n419}
C {devices/lab_pin.sym} 1480.0 20700.0 0 0 {name=l1259 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 21000 0 0 {name=R420 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 20970.0 0 0 {name=l1260 lab=n421}
C {devices/lab_pin.sym} 0.0 21030.0 0 0 {name=l1261 lab=n420}
C {devices/lab_pin.sym} -20.0 21000.0 0 0 {name=l1262 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 21000 0 0 {name=R421 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 20970.0 0 0 {name=l1263 lab=n422}
C {devices/lab_pin.sym} 300.0 21030.0 0 0 {name=l1264 lab=n421}
C {devices/lab_pin.sym} 280.0 21000.0 0 0 {name=l1265 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 21000 0 0 {name=R422 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 20970.0 0 0 {name=l1266 lab=n423}
C {devices/lab_pin.sym} 600.0 21030.0 0 0 {name=l1267 lab=n422}
C {devices/lab_pin.sym} 580.0 21000.0 0 0 {name=l1268 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 21000 0 0 {name=R423 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 20970.0 0 0 {name=l1269 lab=n424}
C {devices/lab_pin.sym} 900.0 21030.0 0 0 {name=l1270 lab=n423}
C {devices/lab_pin.sym} 880.0 21000.0 0 0 {name=l1271 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 21000 0 0 {name=R424 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 20970.0 0 0 {name=l1272 lab=n425}
C {devices/lab_pin.sym} 1200.0 21030.0 0 0 {name=l1273 lab=n424}
C {devices/lab_pin.sym} 1180.0 21000.0 0 0 {name=l1274 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 21000 0 0 {name=R425 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 20970.0 0 0 {name=l1275 lab=n426}
C {devices/lab_pin.sym} 1500.0 21030.0 0 0 {name=l1276 lab=n425}
C {devices/lab_pin.sym} 1480.0 21000.0 0 0 {name=l1277 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 21300 0 0 {name=R426 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 21270.0 0 0 {name=l1278 lab=n427}
C {devices/lab_pin.sym} 0.0 21330.0 0 0 {name=l1279 lab=n426}
C {devices/lab_pin.sym} -20.0 21300.0 0 0 {name=l1280 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 21300 0 0 {name=R427 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 21270.0 0 0 {name=l1281 lab=n428}
C {devices/lab_pin.sym} 300.0 21330.0 0 0 {name=l1282 lab=n427}
C {devices/lab_pin.sym} 280.0 21300.0 0 0 {name=l1283 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 21300 0 0 {name=R428 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 21270.0 0 0 {name=l1284 lab=n429}
C {devices/lab_pin.sym} 600.0 21330.0 0 0 {name=l1285 lab=n428}
C {devices/lab_pin.sym} 580.0 21300.0 0 0 {name=l1286 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 21300 0 0 {name=R429 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 21270.0 0 0 {name=l1287 lab=n430}
C {devices/lab_pin.sym} 900.0 21330.0 0 0 {name=l1288 lab=n429}
C {devices/lab_pin.sym} 880.0 21300.0 0 0 {name=l1289 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 21300 0 0 {name=R430 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 21270.0 0 0 {name=l1290 lab=n431}
C {devices/lab_pin.sym} 1200.0 21330.0 0 0 {name=l1291 lab=n430}
C {devices/lab_pin.sym} 1180.0 21300.0 0 0 {name=l1292 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 21300 0 0 {name=R431 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 21270.0 0 0 {name=l1293 lab=n432}
C {devices/lab_pin.sym} 1500.0 21330.0 0 0 {name=l1294 lab=n431}
C {devices/lab_pin.sym} 1480.0 21300.0 0 0 {name=l1295 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 21600 0 0 {name=R432 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 21570.0 0 0 {name=l1296 lab=n433}
C {devices/lab_pin.sym} 0.0 21630.0 0 0 {name=l1297 lab=n432}
C {devices/lab_pin.sym} -20.0 21600.0 0 0 {name=l1298 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 21600 0 0 {name=R433 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 21570.0 0 0 {name=l1299 lab=n434}
C {devices/lab_pin.sym} 300.0 21630.0 0 0 {name=l1300 lab=n433}
C {devices/lab_pin.sym} 280.0 21600.0 0 0 {name=l1301 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 21600 0 0 {name=R434 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 21570.0 0 0 {name=l1302 lab=n435}
C {devices/lab_pin.sym} 600.0 21630.0 0 0 {name=l1303 lab=n434}
C {devices/lab_pin.sym} 580.0 21600.0 0 0 {name=l1304 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 21600 0 0 {name=R435 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 21570.0 0 0 {name=l1305 lab=n436}
C {devices/lab_pin.sym} 900.0 21630.0 0 0 {name=l1306 lab=n435}
C {devices/lab_pin.sym} 880.0 21600.0 0 0 {name=l1307 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 21600 0 0 {name=R436 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 21570.0 0 0 {name=l1308 lab=n437}
C {devices/lab_pin.sym} 1200.0 21630.0 0 0 {name=l1309 lab=n436}
C {devices/lab_pin.sym} 1180.0 21600.0 0 0 {name=l1310 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 21600 0 0 {name=R437 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 21570.0 0 0 {name=l1311 lab=n438}
C {devices/lab_pin.sym} 1500.0 21630.0 0 0 {name=l1312 lab=n437}
C {devices/lab_pin.sym} 1480.0 21600.0 0 0 {name=l1313 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 21900 0 0 {name=R438 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 21870.0 0 0 {name=l1314 lab=n439}
C {devices/lab_pin.sym} 0.0 21930.0 0 0 {name=l1315 lab=n438}
C {devices/lab_pin.sym} -20.0 21900.0 0 0 {name=l1316 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 21900 0 0 {name=R439 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 21870.0 0 0 {name=l1317 lab=n440}
C {devices/lab_pin.sym} 300.0 21930.0 0 0 {name=l1318 lab=n439}
C {devices/lab_pin.sym} 280.0 21900.0 0 0 {name=l1319 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 21900 0 0 {name=R440 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 21870.0 0 0 {name=l1320 lab=n441}
C {devices/lab_pin.sym} 600.0 21930.0 0 0 {name=l1321 lab=n440}
C {devices/lab_pin.sym} 580.0 21900.0 0 0 {name=l1322 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 21900 0 0 {name=R441 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 21870.0 0 0 {name=l1323 lab=n442}
C {devices/lab_pin.sym} 900.0 21930.0 0 0 {name=l1324 lab=n441}
C {devices/lab_pin.sym} 880.0 21900.0 0 0 {name=l1325 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 21900 0 0 {name=R442 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 21870.0 0 0 {name=l1326 lab=n443}
C {devices/lab_pin.sym} 1200.0 21930.0 0 0 {name=l1327 lab=n442}
C {devices/lab_pin.sym} 1180.0 21900.0 0 0 {name=l1328 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 21900 0 0 {name=R443 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 21870.0 0 0 {name=l1329 lab=n444}
C {devices/lab_pin.sym} 1500.0 21930.0 0 0 {name=l1330 lab=n443}
C {devices/lab_pin.sym} 1480.0 21900.0 0 0 {name=l1331 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 22200 0 0 {name=R444 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 22170.0 0 0 {name=l1332 lab=n445}
C {devices/lab_pin.sym} 0.0 22230.0 0 0 {name=l1333 lab=n444}
C {devices/lab_pin.sym} -20.0 22200.0 0 0 {name=l1334 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 22200 0 0 {name=R445 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 22170.0 0 0 {name=l1335 lab=n446}
C {devices/lab_pin.sym} 300.0 22230.0 0 0 {name=l1336 lab=n445}
C {devices/lab_pin.sym} 280.0 22200.0 0 0 {name=l1337 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 22200 0 0 {name=R446 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 22170.0 0 0 {name=l1338 lab=n447}
C {devices/lab_pin.sym} 600.0 22230.0 0 0 {name=l1339 lab=n446}
C {devices/lab_pin.sym} 580.0 22200.0 0 0 {name=l1340 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 22200 0 0 {name=R447 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 22170.0 0 0 {name=l1341 lab=n448}
C {devices/lab_pin.sym} 900.0 22230.0 0 0 {name=l1342 lab=n447}
C {devices/lab_pin.sym} 880.0 22200.0 0 0 {name=l1343 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 22200 0 0 {name=R448 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 22170.0 0 0 {name=l1344 lab=n449}
C {devices/lab_pin.sym} 1200.0 22230.0 0 0 {name=l1345 lab=n448}
C {devices/lab_pin.sym} 1180.0 22200.0 0 0 {name=l1346 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 22200 0 0 {name=R449 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 22170.0 0 0 {name=l1347 lab=n450}
C {devices/lab_pin.sym} 1500.0 22230.0 0 0 {name=l1348 lab=n449}
C {devices/lab_pin.sym} 1480.0 22200.0 0 0 {name=l1349 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 22500 0 0 {name=R450 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 22470.0 0 0 {name=l1350 lab=n451}
C {devices/lab_pin.sym} 0.0 22530.0 0 0 {name=l1351 lab=n450}
C {devices/lab_pin.sym} -20.0 22500.0 0 0 {name=l1352 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 22500 0 0 {name=R451 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 22470.0 0 0 {name=l1353 lab=n452}
C {devices/lab_pin.sym} 300.0 22530.0 0 0 {name=l1354 lab=n451}
C {devices/lab_pin.sym} 280.0 22500.0 0 0 {name=l1355 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 22500 0 0 {name=R452 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 22470.0 0 0 {name=l1356 lab=n453}
C {devices/lab_pin.sym} 600.0 22530.0 0 0 {name=l1357 lab=n452}
C {devices/lab_pin.sym} 580.0 22500.0 0 0 {name=l1358 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 22500 0 0 {name=R453 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 22470.0 0 0 {name=l1359 lab=n454}
C {devices/lab_pin.sym} 900.0 22530.0 0 0 {name=l1360 lab=n453}
C {devices/lab_pin.sym} 880.0 22500.0 0 0 {name=l1361 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 22500 0 0 {name=R454 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 22470.0 0 0 {name=l1362 lab=n455}
C {devices/lab_pin.sym} 1200.0 22530.0 0 0 {name=l1363 lab=n454}
C {devices/lab_pin.sym} 1180.0 22500.0 0 0 {name=l1364 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 22500 0 0 {name=R455 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 22470.0 0 0 {name=l1365 lab=n456}
C {devices/lab_pin.sym} 1500.0 22530.0 0 0 {name=l1366 lab=n455}
C {devices/lab_pin.sym} 1480.0 22500.0 0 0 {name=l1367 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 22800 0 0 {name=R456 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 22770.0 0 0 {name=l1368 lab=n457}
C {devices/lab_pin.sym} 0.0 22830.0 0 0 {name=l1369 lab=n456}
C {devices/lab_pin.sym} -20.0 22800.0 0 0 {name=l1370 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 22800 0 0 {name=R457 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 22770.0 0 0 {name=l1371 lab=n458}
C {devices/lab_pin.sym} 300.0 22830.0 0 0 {name=l1372 lab=n457}
C {devices/lab_pin.sym} 280.0 22800.0 0 0 {name=l1373 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 22800 0 0 {name=R458 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 22770.0 0 0 {name=l1374 lab=n459}
C {devices/lab_pin.sym} 600.0 22830.0 0 0 {name=l1375 lab=n458}
C {devices/lab_pin.sym} 580.0 22800.0 0 0 {name=l1376 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 22800 0 0 {name=R459 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 22770.0 0 0 {name=l1377 lab=n460}
C {devices/lab_pin.sym} 900.0 22830.0 0 0 {name=l1378 lab=n459}
C {devices/lab_pin.sym} 880.0 22800.0 0 0 {name=l1379 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 22800 0 0 {name=R460 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 22770.0 0 0 {name=l1380 lab=n461}
C {devices/lab_pin.sym} 1200.0 22830.0 0 0 {name=l1381 lab=n460}
C {devices/lab_pin.sym} 1180.0 22800.0 0 0 {name=l1382 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 22800 0 0 {name=R461 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 22770.0 0 0 {name=l1383 lab=n462}
C {devices/lab_pin.sym} 1500.0 22830.0 0 0 {name=l1384 lab=n461}
C {devices/lab_pin.sym} 1480.0 22800.0 0 0 {name=l1385 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 23100 0 0 {name=R462 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 23070.0 0 0 {name=l1386 lab=n463}
C {devices/lab_pin.sym} 0.0 23130.0 0 0 {name=l1387 lab=n462}
C {devices/lab_pin.sym} -20.0 23100.0 0 0 {name=l1388 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 23100 0 0 {name=R463 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 23070.0 0 0 {name=l1389 lab=n464}
C {devices/lab_pin.sym} 300.0 23130.0 0 0 {name=l1390 lab=n463}
C {devices/lab_pin.sym} 280.0 23100.0 0 0 {name=l1391 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 23100 0 0 {name=R464 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 23070.0 0 0 {name=l1392 lab=n465}
C {devices/lab_pin.sym} 600.0 23130.0 0 0 {name=l1393 lab=n464}
C {devices/lab_pin.sym} 580.0 23100.0 0 0 {name=l1394 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 23100 0 0 {name=R465 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 23070.0 0 0 {name=l1395 lab=n466}
C {devices/lab_pin.sym} 900.0 23130.0 0 0 {name=l1396 lab=n465}
C {devices/lab_pin.sym} 880.0 23100.0 0 0 {name=l1397 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 23100 0 0 {name=R466 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 23070.0 0 0 {name=l1398 lab=n467}
C {devices/lab_pin.sym} 1200.0 23130.0 0 0 {name=l1399 lab=n466}
C {devices/lab_pin.sym} 1180.0 23100.0 0 0 {name=l1400 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 23100 0 0 {name=R467 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 23070.0 0 0 {name=l1401 lab=n468}
C {devices/lab_pin.sym} 1500.0 23130.0 0 0 {name=l1402 lab=n467}
C {devices/lab_pin.sym} 1480.0 23100.0 0 0 {name=l1403 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 23400 0 0 {name=R468 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 23370.0 0 0 {name=l1404 lab=n469}
C {devices/lab_pin.sym} 0.0 23430.0 0 0 {name=l1405 lab=n468}
C {devices/lab_pin.sym} -20.0 23400.0 0 0 {name=l1406 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 23400 0 0 {name=R469 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 23370.0 0 0 {name=l1407 lab=n470}
C {devices/lab_pin.sym} 300.0 23430.0 0 0 {name=l1408 lab=n469}
C {devices/lab_pin.sym} 280.0 23400.0 0 0 {name=l1409 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 23400 0 0 {name=R470 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 23370.0 0 0 {name=l1410 lab=n471}
C {devices/lab_pin.sym} 600.0 23430.0 0 0 {name=l1411 lab=n470}
C {devices/lab_pin.sym} 580.0 23400.0 0 0 {name=l1412 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 23400 0 0 {name=R471 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 23370.0 0 0 {name=l1413 lab=n472}
C {devices/lab_pin.sym} 900.0 23430.0 0 0 {name=l1414 lab=n471}
C {devices/lab_pin.sym} 880.0 23400.0 0 0 {name=l1415 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 23400 0 0 {name=R472 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 23370.0 0 0 {name=l1416 lab=n473}
C {devices/lab_pin.sym} 1200.0 23430.0 0 0 {name=l1417 lab=n472}
C {devices/lab_pin.sym} 1180.0 23400.0 0 0 {name=l1418 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 23400 0 0 {name=R473 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 23370.0 0 0 {name=l1419 lab=n474}
C {devices/lab_pin.sym} 1500.0 23430.0 0 0 {name=l1420 lab=n473}
C {devices/lab_pin.sym} 1480.0 23400.0 0 0 {name=l1421 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 23700 0 0 {name=R474 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 23670.0 0 0 {name=l1422 lab=n475}
C {devices/lab_pin.sym} 0.0 23730.0 0 0 {name=l1423 lab=n474}
C {devices/lab_pin.sym} -20.0 23700.0 0 0 {name=l1424 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 23700 0 0 {name=R475 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 23670.0 0 0 {name=l1425 lab=n476}
C {devices/lab_pin.sym} 300.0 23730.0 0 0 {name=l1426 lab=n475}
C {devices/lab_pin.sym} 280.0 23700.0 0 0 {name=l1427 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 23700 0 0 {name=R476 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 23670.0 0 0 {name=l1428 lab=n477}
C {devices/lab_pin.sym} 600.0 23730.0 0 0 {name=l1429 lab=n476}
C {devices/lab_pin.sym} 580.0 23700.0 0 0 {name=l1430 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 23700 0 0 {name=R477 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 23670.0 0 0 {name=l1431 lab=n478}
C {devices/lab_pin.sym} 900.0 23730.0 0 0 {name=l1432 lab=n477}
C {devices/lab_pin.sym} 880.0 23700.0 0 0 {name=l1433 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 23700 0 0 {name=R478 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 23670.0 0 0 {name=l1434 lab=n479}
C {devices/lab_pin.sym} 1200.0 23730.0 0 0 {name=l1435 lab=n478}
C {devices/lab_pin.sym} 1180.0 23700.0 0 0 {name=l1436 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 23700 0 0 {name=R479 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 23670.0 0 0 {name=l1437 lab=n480}
C {devices/lab_pin.sym} 1500.0 23730.0 0 0 {name=l1438 lab=n479}
C {devices/lab_pin.sym} 1480.0 23700.0 0 0 {name=l1439 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 24000 0 0 {name=R480 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 23970.0 0 0 {name=l1440 lab=n481}
C {devices/lab_pin.sym} 0.0 24030.0 0 0 {name=l1441 lab=n480}
C {devices/lab_pin.sym} -20.0 24000.0 0 0 {name=l1442 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 24000 0 0 {name=R481 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 23970.0 0 0 {name=l1443 lab=n482}
C {devices/lab_pin.sym} 300.0 24030.0 0 0 {name=l1444 lab=n481}
C {devices/lab_pin.sym} 280.0 24000.0 0 0 {name=l1445 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 24000 0 0 {name=R482 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 23970.0 0 0 {name=l1446 lab=n483}
C {devices/lab_pin.sym} 600.0 24030.0 0 0 {name=l1447 lab=n482}
C {devices/lab_pin.sym} 580.0 24000.0 0 0 {name=l1448 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 24000 0 0 {name=R483 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 23970.0 0 0 {name=l1449 lab=n484}
C {devices/lab_pin.sym} 900.0 24030.0 0 0 {name=l1450 lab=n483}
C {devices/lab_pin.sym} 880.0 24000.0 0 0 {name=l1451 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 24000 0 0 {name=R484 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 23970.0 0 0 {name=l1452 lab=n485}
C {devices/lab_pin.sym} 1200.0 24030.0 0 0 {name=l1453 lab=n484}
C {devices/lab_pin.sym} 1180.0 24000.0 0 0 {name=l1454 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 24000 0 0 {name=R485 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 23970.0 0 0 {name=l1455 lab=n486}
C {devices/lab_pin.sym} 1500.0 24030.0 0 0 {name=l1456 lab=n485}
C {devices/lab_pin.sym} 1480.0 24000.0 0 0 {name=l1457 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 24300 0 0 {name=R486 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 24270.0 0 0 {name=l1458 lab=n487}
C {devices/lab_pin.sym} 0.0 24330.0 0 0 {name=l1459 lab=n486}
C {devices/lab_pin.sym} -20.0 24300.0 0 0 {name=l1460 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 24300 0 0 {name=R487 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 24270.0 0 0 {name=l1461 lab=n488}
C {devices/lab_pin.sym} 300.0 24330.0 0 0 {name=l1462 lab=n487}
C {devices/lab_pin.sym} 280.0 24300.0 0 0 {name=l1463 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 24300 0 0 {name=R488 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 24270.0 0 0 {name=l1464 lab=n489}
C {devices/lab_pin.sym} 600.0 24330.0 0 0 {name=l1465 lab=n488}
C {devices/lab_pin.sym} 580.0 24300.0 0 0 {name=l1466 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 24300 0 0 {name=R489 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 24270.0 0 0 {name=l1467 lab=n490}
C {devices/lab_pin.sym} 900.0 24330.0 0 0 {name=l1468 lab=n489}
C {devices/lab_pin.sym} 880.0 24300.0 0 0 {name=l1469 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 24300 0 0 {name=R490 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 24270.0 0 0 {name=l1470 lab=n491}
C {devices/lab_pin.sym} 1200.0 24330.0 0 0 {name=l1471 lab=n490}
C {devices/lab_pin.sym} 1180.0 24300.0 0 0 {name=l1472 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 24300 0 0 {name=R491 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 24270.0 0 0 {name=l1473 lab=n492}
C {devices/lab_pin.sym} 1500.0 24330.0 0 0 {name=l1474 lab=n491}
C {devices/lab_pin.sym} 1480.0 24300.0 0 0 {name=l1475 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 24600 0 0 {name=R492 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 24570.0 0 0 {name=l1476 lab=n493}
C {devices/lab_pin.sym} 0.0 24630.0 0 0 {name=l1477 lab=n492}
C {devices/lab_pin.sym} -20.0 24600.0 0 0 {name=l1478 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 24600 0 0 {name=R493 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 24570.0 0 0 {name=l1479 lab=n494}
C {devices/lab_pin.sym} 300.0 24630.0 0 0 {name=l1480 lab=n493}
C {devices/lab_pin.sym} 280.0 24600.0 0 0 {name=l1481 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 24600 0 0 {name=R494 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 24570.0 0 0 {name=l1482 lab=n495}
C {devices/lab_pin.sym} 600.0 24630.0 0 0 {name=l1483 lab=n494}
C {devices/lab_pin.sym} 580.0 24600.0 0 0 {name=l1484 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 24600 0 0 {name=R495 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 24570.0 0 0 {name=l1485 lab=n496}
C {devices/lab_pin.sym} 900.0 24630.0 0 0 {name=l1486 lab=n495}
C {devices/lab_pin.sym} 880.0 24600.0 0 0 {name=l1487 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 24600 0 0 {name=R496 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 24570.0 0 0 {name=l1488 lab=n497}
C {devices/lab_pin.sym} 1200.0 24630.0 0 0 {name=l1489 lab=n496}
C {devices/lab_pin.sym} 1180.0 24600.0 0 0 {name=l1490 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 24600 0 0 {name=R497 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 24570.0 0 0 {name=l1491 lab=n498}
C {devices/lab_pin.sym} 1500.0 24630.0 0 0 {name=l1492 lab=n497}
C {devices/lab_pin.sym} 1480.0 24600.0 0 0 {name=l1493 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 24900 0 0 {name=R498 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 24870.0 0 0 {name=l1494 lab=n499}
C {devices/lab_pin.sym} 0.0 24930.0 0 0 {name=l1495 lab=n498}
C {devices/lab_pin.sym} -20.0 24900.0 0 0 {name=l1496 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 24900 0 0 {name=R499 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 24870.0 0 0 {name=l1497 lab=n500}
C {devices/lab_pin.sym} 300.0 24930.0 0 0 {name=l1498 lab=n499}
C {devices/lab_pin.sym} 280.0 24900.0 0 0 {name=l1499 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 24900 0 0 {name=R500 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 24870.0 0 0 {name=l1500 lab=n501}
C {devices/lab_pin.sym} 600.0 24930.0 0 0 {name=l1501 lab=n500}
C {devices/lab_pin.sym} 580.0 24900.0 0 0 {name=l1502 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 24900 0 0 {name=R501 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 24870.0 0 0 {name=l1503 lab=n502}
C {devices/lab_pin.sym} 900.0 24930.0 0 0 {name=l1504 lab=n501}
C {devices/lab_pin.sym} 880.0 24900.0 0 0 {name=l1505 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 24900 0 0 {name=R502 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 24870.0 0 0 {name=l1506 lab=n503}
C {devices/lab_pin.sym} 1200.0 24930.0 0 0 {name=l1507 lab=n502}
C {devices/lab_pin.sym} 1180.0 24900.0 0 0 {name=l1508 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 24900 0 0 {name=R503 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 24870.0 0 0 {name=l1509 lab=n504}
C {devices/lab_pin.sym} 1500.0 24930.0 0 0 {name=l1510 lab=n503}
C {devices/lab_pin.sym} 1480.0 24900.0 0 0 {name=l1511 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 25200 0 0 {name=R504 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 25170.0 0 0 {name=l1512 lab=n505}
C {devices/lab_pin.sym} 0.0 25230.0 0 0 {name=l1513 lab=n504}
C {devices/lab_pin.sym} -20.0 25200.0 0 0 {name=l1514 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 25200 0 0 {name=R505 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 25170.0 0 0 {name=l1515 lab=n506}
C {devices/lab_pin.sym} 300.0 25230.0 0 0 {name=l1516 lab=n505}
C {devices/lab_pin.sym} 280.0 25200.0 0 0 {name=l1517 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 25200 0 0 {name=R506 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 25170.0 0 0 {name=l1518 lab=n507}
C {devices/lab_pin.sym} 600.0 25230.0 0 0 {name=l1519 lab=n506}
C {devices/lab_pin.sym} 580.0 25200.0 0 0 {name=l1520 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 25200 0 0 {name=R507 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 25170.0 0 0 {name=l1521 lab=n508}
C {devices/lab_pin.sym} 900.0 25230.0 0 0 {name=l1522 lab=n507}
C {devices/lab_pin.sym} 880.0 25200.0 0 0 {name=l1523 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 25200 0 0 {name=R508 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 25170.0 0 0 {name=l1524 lab=n509}
C {devices/lab_pin.sym} 1200.0 25230.0 0 0 {name=l1525 lab=n508}
C {devices/lab_pin.sym} 1180.0 25200.0 0 0 {name=l1526 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 25200 0 0 {name=R509 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 25170.0 0 0 {name=l1527 lab=n510}
C {devices/lab_pin.sym} 1500.0 25230.0 0 0 {name=l1528 lab=n509}
C {devices/lab_pin.sym} 1480.0 25200.0 0 0 {name=l1529 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 25500 0 0 {name=R510 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 25470.0 0 0 {name=l1530 lab=n511}
C {devices/lab_pin.sym} 0.0 25530.0 0 0 {name=l1531 lab=n510}
C {devices/lab_pin.sym} -20.0 25500.0 0 0 {name=l1532 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 25500 0 0 {name=R511 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 25470.0 0 0 {name=l1533 lab=n512}
C {devices/lab_pin.sym} 300.0 25530.0 0 0 {name=l1534 lab=n511}
C {devices/lab_pin.sym} 280.0 25500.0 0 0 {name=l1535 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 25500 0 0 {name=R512 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 25470.0 0 0 {name=l1536 lab=n513}
C {devices/lab_pin.sym} 600.0 25530.0 0 0 {name=l1537 lab=n512}
C {devices/lab_pin.sym} 580.0 25500.0 0 0 {name=l1538 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 25500 0 0 {name=R513 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 25470.0 0 0 {name=l1539 lab=n514}
C {devices/lab_pin.sym} 900.0 25530.0 0 0 {name=l1540 lab=n513}
C {devices/lab_pin.sym} 880.0 25500.0 0 0 {name=l1541 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1200 25500 0 0 {name=R514 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1200.0 25470.0 0 0 {name=l1542 lab=n515}
C {devices/lab_pin.sym} 1200.0 25530.0 0 0 {name=l1543 lab=n514}
C {devices/lab_pin.sym} 1180.0 25500.0 0 0 {name=l1544 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 1500 25500 0 0 {name=R515 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 1500.0 25470.0 0 0 {name=l1545 lab=n516}
C {devices/lab_pin.sym} 1500.0 25530.0 0 0 {name=l1546 lab=n515}
C {devices/lab_pin.sym} 1480.0 25500.0 0 0 {name=l1547 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 0 25800 0 0 {name=R516 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 0.0 25770.0 0 0 {name=l1548 lab=n517}
C {devices/lab_pin.sym} 0.0 25830.0 0 0 {name=l1549 lab=n516}
C {devices/lab_pin.sym} -20.0 25800.0 0 0 {name=l1550 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 300 25800 0 0 {name=R517 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 300.0 25770.0 0 0 {name=l1551 lab=n518}
C {devices/lab_pin.sym} 300.0 25830.0 0 0 {name=l1552 lab=n517}
C {devices/lab_pin.sym} 280.0 25800.0 0 0 {name=l1553 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 600 25800 0 0 {name=R518 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 600.0 25770.0 0 0 {name=l1554 lab=n519}
C {devices/lab_pin.sym} 600.0 25830.0 0 0 {name=l1555 lab=n518}
C {devices/lab_pin.sym} 580.0 25800.0 0 0 {name=l1556 lab=vss}
C {sky130_fd_pr/res_high_po_1p41.sym} 900 25800 0 0 {name=R519 L=3 mult=1 model=res_high_po_1p41 spiceprefix=X}
C {devices/lab_pin.sym} 900.0 25770.0 0 0 {name=l1557 lab=top}
C {devices/lab_pin.sym} 900.0 25830.0 0 0 {name=l1558 lab=n519}
C {devices/lab_pin.sym} 880.0 25800.0 0 0 {name=l1559 lab=vss}
