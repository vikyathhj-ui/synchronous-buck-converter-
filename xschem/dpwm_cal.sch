v {xschem version=3.4.7RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}

C {devices/iopin.sym} -600 0 0 0 {name=p0 lab=pwm_set}
C {devices/iopin.sym} -600 40 0 0 {name=p1 lab=pwm_rst}
C {devices/iopin.sym} -600 80 0 0 {name=p2 lab=t0}
C {devices/iopin.sym} -600 120 0 0 {name=p3 lab=t1}
C {devices/iopin.sym} -600 160 0 0 {name=p4 lab=t2}
C {devices/iopin.sym} -600 200 0 0 {name=p5 lab=t3}
C {devices/iopin.sym} -600 240 0 0 {name=p6 lab=t4}
C {devices/iopin.sym} -600 280 0 0 {name=p7 lab=t5}
C {devices/iopin.sym} -600 320 0 0 {name=p8 lab=hs_pwm}
C {devices/iopin.sym} -600 360 0 0 {name=p9 lab=vdd}
C {devices/iopin.sym} -600 400 0 0 {name=p10 lab=vss}
C {sky130_stdcells/dlygate4sd3_1.sym} 0 0 0 0 {name=XE0 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} -40.0 0.0 0 0 {name=l0 lab=pwm_rst}
C {devices/lab_pin.sym} 40.0 0.0 0 0 {name=l1 lab=m1}
C {sky130_stdcells/dlygate4sd3_1.sym} 300 0 0 0 {name=XE1 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 260.0 0.0 0 0 {name=l2 lab=m1}
C {devices/lab_pin.sym} 340.0 0.0 0 0 {name=l3 lab=m2}
C {sky130_stdcells/dlygate4sd3_1.sym} 600 0 0 0 {name=XE2 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 560.0 0.0 0 0 {name=l4 lab=m2}
C {devices/lab_pin.sym} 640.0 0.0 0 0 {name=l5 lab=m3}
C {sky130_stdcells/dlygate4sd3_1.sym} 900 0 0 0 {name=XE3 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 860.0 0.0 0 0 {name=l6 lab=m3}
C {devices/lab_pin.sym} 940.0 0.0 0 0 {name=l7 lab=m4}
C {sky130_stdcells/dlygate4sd3_1.sym} 1200 0 0 0 {name=XE4 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1160.0 0.0 0 0 {name=l8 lab=m4}
C {devices/lab_pin.sym} 1240.0 0.0 0 0 {name=l9 lab=m5}
C {sky130_stdcells/dlygate4sd3_1.sym} 1500 0 0 0 {name=XE5 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1460.0 0.0 0 0 {name=l10 lab=m5}
C {devices/lab_pin.sym} 1540.0 0.0 0 0 {name=l11 lab=m6}
C {sky130_stdcells/dlygate4sd3_1.sym} 0 300 0 0 {name=XE6 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} -40.0 300.0 0 0 {name=l12 lab=m6}
C {devices/lab_pin.sym} 40.0 300.0 0 0 {name=l13 lab=m7}
C {sky130_stdcells/dlygate4sd3_1.sym} 300 300 0 0 {name=XE7 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 260.0 300.0 0 0 {name=l14 lab=m7}
C {devices/lab_pin.sym} 340.0 300.0 0 0 {name=l15 lab=m8}
C {sky130_stdcells/dlygate4sd3_1.sym} 600 300 0 0 {name=XE8 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 560.0 300.0 0 0 {name=l16 lab=m8}
C {devices/lab_pin.sym} 640.0 300.0 0 0 {name=l17 lab=m9}
C {sky130_stdcells/dlygate4sd3_1.sym} 900 300 0 0 {name=XE9 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 860.0 300.0 0 0 {name=l18 lab=m9}
C {devices/lab_pin.sym} 940.0 300.0 0 0 {name=l19 lab=m10}
C {sky130_stdcells/dlygate4sd3_1.sym} 1200 300 0 0 {name=XE10 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1160.0 300.0 0 0 {name=l20 lab=m10}
C {devices/lab_pin.sym} 1240.0 300.0 0 0 {name=l21 lab=m11}
C {sky130_stdcells/dlygate4sd3_1.sym} 1500 300 0 0 {name=XE11 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1460.0 300.0 0 0 {name=l22 lab=m11}
C {devices/lab_pin.sym} 1540.0 300.0 0 0 {name=l23 lab=m12}
C {sky130_stdcells/dlygate4sd3_1.sym} 0 600 0 0 {name=XE12 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} -40.0 600.0 0 0 {name=l24 lab=m12}
C {devices/lab_pin.sym} 40.0 600.0 0 0 {name=l25 lab=m13}
C {sky130_stdcells/dlygate4sd3_1.sym} 300 600 0 0 {name=XE13 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 260.0 600.0 0 0 {name=l26 lab=m13}
C {devices/lab_pin.sym} 340.0 600.0 0 0 {name=l27 lab=m14}
C {sky130_stdcells/dlygate4sd3_1.sym} 600 600 0 0 {name=XE14 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 560.0 600.0 0 0 {name=l28 lab=m14}
C {devices/lab_pin.sym} 640.0 600.0 0 0 {name=l29 lab=m15}
C {sky130_stdcells/dlygate4sd3_1.sym} 900 600 0 0 {name=XE15 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 860.0 600.0 0 0 {name=l30 lab=m15}
C {devices/lab_pin.sym} 940.0 600.0 0 0 {name=l31 lab=m16}
C {sky130_stdcells/dlygate4sd3_1.sym} 1200 600 0 0 {name=XE16 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1160.0 600.0 0 0 {name=l32 lab=m16}
C {devices/lab_pin.sym} 1240.0 600.0 0 0 {name=l33 lab=m17}
C {sky130_stdcells/dlygate4sd3_1.sym} 1500 600 0 0 {name=XE17 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1460.0 600.0 0 0 {name=l34 lab=m17}
C {devices/lab_pin.sym} 1540.0 600.0 0 0 {name=l35 lab=m18}
C {sky130_stdcells/dlygate4sd3_1.sym} 0 900 0 0 {name=XE18 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} -40.0 900.0 0 0 {name=l36 lab=m18}
C {devices/lab_pin.sym} 40.0 900.0 0 0 {name=l37 lab=m19}
C {sky130_stdcells/dlygate4sd3_1.sym} 300 900 0 0 {name=XE19 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 260.0 900.0 0 0 {name=l38 lab=m19}
C {devices/lab_pin.sym} 340.0 900.0 0 0 {name=l39 lab=m20}
C {sky130_stdcells/dlygate4sd3_1.sym} 600 900 0 0 {name=XE20 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 560.0 900.0 0 0 {name=l40 lab=m20}
C {devices/lab_pin.sym} 640.0 900.0 0 0 {name=l41 lab=m21}
C {sky130_stdcells/dlygate4sd3_1.sym} 900 900 0 0 {name=XE21 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 860.0 900.0 0 0 {name=l42 lab=m21}
C {devices/lab_pin.sym} 940.0 900.0 0 0 {name=l43 lab=m22}
C {sky130_stdcells/dlygate4sd3_1.sym} 1200 900 0 0 {name=XE22 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1160.0 900.0 0 0 {name=l44 lab=m22}
C {devices/lab_pin.sym} 1240.0 900.0 0 0 {name=l45 lab=m23}
C {sky130_stdcells/dlygate4sd3_1.sym} 1500 900 0 0 {name=XE23 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1460.0 900.0 0 0 {name=l46 lab=m23}
C {devices/lab_pin.sym} 1540.0 900.0 0 0 {name=l47 lab=m24}
C {sky130_stdcells/dlygate4sd3_1.sym} 0 1200 0 0 {name=XE24 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} -40.0 1200.0 0 0 {name=l48 lab=m24}
C {devices/lab_pin.sym} 40.0 1200.0 0 0 {name=l49 lab=m25}
C {sky130_stdcells/dlygate4sd3_1.sym} 300 1200 0 0 {name=XE25 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 260.0 1200.0 0 0 {name=l50 lab=m25}
C {devices/lab_pin.sym} 340.0 1200.0 0 0 {name=l51 lab=m26}
C {sky130_stdcells/dlygate4sd3_1.sym} 600 1200 0 0 {name=XE26 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 560.0 1200.0 0 0 {name=l52 lab=m26}
C {devices/lab_pin.sym} 640.0 1200.0 0 0 {name=l53 lab=m27}
C {sky130_stdcells/dlygate4sd3_1.sym} 900 1200 0 0 {name=XE27 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 860.0 1200.0 0 0 {name=l54 lab=m27}
C {devices/lab_pin.sym} 940.0 1200.0 0 0 {name=l55 lab=m28}
C {sky130_stdcells/dlygate4sd3_1.sym} 1200 1200 0 0 {name=XE28 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1160.0 1200.0 0 0 {name=l56 lab=m28}
C {devices/lab_pin.sym} 1240.0 1200.0 0 0 {name=l57 lab=m29}
C {sky130_stdcells/dlygate4sd3_1.sym} 1500 1200 0 0 {name=XE29 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1460.0 1200.0 0 0 {name=l58 lab=m29}
C {devices/lab_pin.sym} 1540.0 1200.0 0 0 {name=l59 lab=m30}
C {sky130_stdcells/dlygate4sd3_1.sym} 0 1500 0 0 {name=XE30 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} -40.0 1500.0 0 0 {name=l60 lab=m30}
C {devices/lab_pin.sym} 40.0 1500.0 0 0 {name=l61 lab=m31}
C {sky130_stdcells/dlygate4sd3_1.sym} 300 1500 0 0 {name=XE31 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 260.0 1500.0 0 0 {name=l62 lab=m31}
C {devices/lab_pin.sym} 340.0 1500.0 0 0 {name=l63 lab=m32}
C {sky130_stdcells/dlygate4sd3_1.sym} 600 1500 0 0 {name=XE32 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 560.0 1500.0 0 0 {name=l64 lab=m32}
C {devices/lab_pin.sym} 640.0 1500.0 0 0 {name=l65 lab=m33}
C {sky130_stdcells/dlygate4sd3_1.sym} 900 1500 0 0 {name=XE33 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 860.0 1500.0 0 0 {name=l66 lab=m33}
C {devices/lab_pin.sym} 940.0 1500.0 0 0 {name=l67 lab=m34}
C {sky130_stdcells/dlygate4sd3_1.sym} 1200 1500 0 0 {name=XE34 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1160.0 1500.0 0 0 {name=l68 lab=m34}
C {devices/lab_pin.sym} 1240.0 1500.0 0 0 {name=l69 lab=m35}
C {sky130_stdcells/dlygate4sd3_1.sym} 1500 1500 0 0 {name=XE35 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1460.0 1500.0 0 0 {name=l70 lab=m35}
C {devices/lab_pin.sym} 1540.0 1500.0 0 0 {name=l71 lab=m36}
C {sky130_stdcells/dlygate4sd3_1.sym} 0 1800 0 0 {name=XE36 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} -40.0 1800.0 0 0 {name=l72 lab=m36}
C {devices/lab_pin.sym} 40.0 1800.0 0 0 {name=l73 lab=m37}
C {sky130_stdcells/dlygate4sd3_1.sym} 300 1800 0 0 {name=XE37 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 260.0 1800.0 0 0 {name=l74 lab=m37}
C {devices/lab_pin.sym} 340.0 1800.0 0 0 {name=l75 lab=m38}
C {sky130_stdcells/dlygate4sd3_1.sym} 600 1800 0 0 {name=XE38 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 560.0 1800.0 0 0 {name=l76 lab=m38}
C {devices/lab_pin.sym} 640.0 1800.0 0 0 {name=l77 lab=m39}
C {sky130_stdcells/dlygate4sd3_1.sym} 900 1800 0 0 {name=XE39 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 860.0 1800.0 0 0 {name=l78 lab=m39}
C {devices/lab_pin.sym} 940.0 1800.0 0 0 {name=l79 lab=m40}
C {sky130_stdcells/dlygate4sd3_1.sym} 1200 1800 0 0 {name=XE40 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1160.0 1800.0 0 0 {name=l80 lab=m40}
C {devices/lab_pin.sym} 1240.0 1800.0 0 0 {name=l81 lab=m41}
C {sky130_stdcells/dlygate4sd3_1.sym} 1500 1800 0 0 {name=XE41 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1460.0 1800.0 0 0 {name=l82 lab=m41}
C {devices/lab_pin.sym} 1540.0 1800.0 0 0 {name=l83 lab=m42}
C {sky130_stdcells/dlygate4sd3_1.sym} 0 2100 0 0 {name=XE42 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} -40.0 2100.0 0 0 {name=l84 lab=m42}
C {devices/lab_pin.sym} 40.0 2100.0 0 0 {name=l85 lab=m43}
C {sky130_stdcells/dlygate4sd3_1.sym} 300 2100 0 0 {name=XE43 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 260.0 2100.0 0 0 {name=l86 lab=m43}
C {devices/lab_pin.sym} 340.0 2100.0 0 0 {name=l87 lab=m44}
C {sky130_stdcells/dlygate4sd3_1.sym} 600 2100 0 0 {name=XE44 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 560.0 2100.0 0 0 {name=l88 lab=m44}
C {devices/lab_pin.sym} 640.0 2100.0 0 0 {name=l89 lab=m45}
C {sky130_stdcells/dlygate4sd3_1.sym} 900 2100 0 0 {name=XE45 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 860.0 2100.0 0 0 {name=l90 lab=m45}
C {devices/lab_pin.sym} 940.0 2100.0 0 0 {name=l91 lab=m46}
C {sky130_stdcells/dlygate4sd3_1.sym} 1200 2100 0 0 {name=XE46 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1160.0 2100.0 0 0 {name=l92 lab=m46}
C {devices/lab_pin.sym} 1240.0 2100.0 0 0 {name=l93 lab=m47}
C {sky130_stdcells/dlygate4sd3_1.sym} 1500 2100 0 0 {name=XE47 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1460.0 2100.0 0 0 {name=l94 lab=m47}
C {devices/lab_pin.sym} 1540.0 2100.0 0 0 {name=l95 lab=m48}
C {sky130_stdcells/dlygate4sd3_1.sym} 0 2400 0 0 {name=XE48 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} -40.0 2400.0 0 0 {name=l96 lab=m48}
C {devices/lab_pin.sym} 40.0 2400.0 0 0 {name=l97 lab=m49}
C {sky130_stdcells/dlygate4sd3_1.sym} 300 2400 0 0 {name=XE49 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 260.0 2400.0 0 0 {name=l98 lab=m49}
C {devices/lab_pin.sym} 340.0 2400.0 0 0 {name=l99 lab=m50}
C {sky130_stdcells/dlygate4sd3_1.sym} 600 2400 0 0 {name=XE50 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 560.0 2400.0 0 0 {name=l100 lab=m50}
C {devices/lab_pin.sym} 640.0 2400.0 0 0 {name=l101 lab=m51}
C {sky130_stdcells/dlygate4sd3_1.sym} 900 2400 0 0 {name=XE51 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 860.0 2400.0 0 0 {name=l102 lab=m51}
C {devices/lab_pin.sym} 940.0 2400.0 0 0 {name=l103 lab=m52}
C {sky130_stdcells/dlygate4sd3_1.sym} 1200 2400 0 0 {name=XE52 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1160.0 2400.0 0 0 {name=l104 lab=m52}
C {devices/lab_pin.sym} 1240.0 2400.0 0 0 {name=l105 lab=m53}
C {sky130_stdcells/dlygate4sd3_1.sym} 1500 2400 0 0 {name=XE53 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1460.0 2400.0 0 0 {name=l106 lab=m53}
C {devices/lab_pin.sym} 1540.0 2400.0 0 0 {name=l107 lab=m54}
C {sky130_stdcells/dlygate4sd3_1.sym} 0 2700 0 0 {name=XE54 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} -40.0 2700.0 0 0 {name=l108 lab=m54}
C {devices/lab_pin.sym} 40.0 2700.0 0 0 {name=l109 lab=m55}
C {sky130_stdcells/dlygate4sd3_1.sym} 300 2700 0 0 {name=XE55 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 260.0 2700.0 0 0 {name=l110 lab=m55}
C {devices/lab_pin.sym} 340.0 2700.0 0 0 {name=l111 lab=m56}
C {sky130_stdcells/dlygate4sd3_1.sym} 600 2700 0 0 {name=XE56 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 560.0 2700.0 0 0 {name=l112 lab=m56}
C {devices/lab_pin.sym} 640.0 2700.0 0 0 {name=l113 lab=m57}
C {sky130_stdcells/dlygate4sd3_1.sym} 900 2700 0 0 {name=XE57 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 860.0 2700.0 0 0 {name=l114 lab=m57}
C {devices/lab_pin.sym} 940.0 2700.0 0 0 {name=l115 lab=m58}
C {sky130_stdcells/dlygate4sd3_1.sym} 1200 2700 0 0 {name=XE58 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1160.0 2700.0 0 0 {name=l116 lab=m58}
C {devices/lab_pin.sym} 1240.0 2700.0 0 0 {name=l117 lab=m59}
C {sky130_stdcells/dlygate4sd3_1.sym} 1500 2700 0 0 {name=XE59 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1460.0 2700.0 0 0 {name=l118 lab=m59}
C {devices/lab_pin.sym} 1540.0 2700.0 0 0 {name=l119 lab=m60}
C {sky130_stdcells/dlygate4sd3_1.sym} 0 3000 0 0 {name=XE60 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} -40.0 3000.0 0 0 {name=l120 lab=m60}
C {devices/lab_pin.sym} 40.0 3000.0 0 0 {name=l121 lab=m61}
C {sky130_stdcells/dlygate4sd3_1.sym} 300 3000 0 0 {name=XE61 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 260.0 3000.0 0 0 {name=l122 lab=m61}
C {devices/lab_pin.sym} 340.0 3000.0 0 0 {name=l123 lab=m62}
C {sky130_stdcells/dlygate4sd3_1.sym} 600 3000 0 0 {name=XE62 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 560.0 3000.0 0 0 {name=l124 lab=m62}
C {devices/lab_pin.sym} 640.0 3000.0 0 0 {name=l125 lab=m63}
C {sky130_stdcells/dlygate4sd3_1.sym} 900 3000 0 0 {name=XE63 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 860.0 3000.0 0 0 {name=l126 lab=m63}
C {devices/lab_pin.sym} 940.0 3000.0 0 0 {name=l127 lab=m64}
C {sky130_stdcells/mux2_1.sym} 1200 3000 0 0 {name=XM0_0 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1160.0 2980.0 0 0 {name=l128 lab=pwm_rst}
C {devices/lab_pin.sym} 1160.0 3020.0 0 0 {name=l129 lab=m1}
C {devices/lab_pin.sym} 1160.0 3060.0 0 0 {name=l130 lab=t0}
C {devices/lab_pin.sym} 1240.0 3000.0 0 0 {name=l131 lab=x0_0}
C {sky130_stdcells/mux2_1.sym} 1500 3000 0 0 {name=XM0_1 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1460.0 2980.0 0 0 {name=l132 lab=m2}
C {devices/lab_pin.sym} 1460.0 3020.0 0 0 {name=l133 lab=m3}
C {devices/lab_pin.sym} 1460.0 3060.0 0 0 {name=l134 lab=t0}
C {devices/lab_pin.sym} 1540.0 3000.0 0 0 {name=l135 lab=x0_1}
C {sky130_stdcells/mux2_1.sym} 0 3300 0 0 {name=XM0_2 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} -40.0 3280.0 0 0 {name=l136 lab=m4}
C {devices/lab_pin.sym} -40.0 3320.0 0 0 {name=l137 lab=m5}
C {devices/lab_pin.sym} -40.0 3360.0 0 0 {name=l138 lab=t0}
C {devices/lab_pin.sym} 40.0 3300.0 0 0 {name=l139 lab=x0_2}
C {sky130_stdcells/mux2_1.sym} 300 3300 0 0 {name=XM0_3 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 260.0 3280.0 0 0 {name=l140 lab=m6}
C {devices/lab_pin.sym} 260.0 3320.0 0 0 {name=l141 lab=m7}
C {devices/lab_pin.sym} 260.0 3360.0 0 0 {name=l142 lab=t0}
C {devices/lab_pin.sym} 340.0 3300.0 0 0 {name=l143 lab=x0_3}
C {sky130_stdcells/mux2_1.sym} 600 3300 0 0 {name=XM0_4 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 560.0 3280.0 0 0 {name=l144 lab=m8}
C {devices/lab_pin.sym} 560.0 3320.0 0 0 {name=l145 lab=m9}
C {devices/lab_pin.sym} 560.0 3360.0 0 0 {name=l146 lab=t0}
C {devices/lab_pin.sym} 640.0 3300.0 0 0 {name=l147 lab=x0_4}
C {sky130_stdcells/mux2_1.sym} 900 3300 0 0 {name=XM0_5 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 860.0 3280.0 0 0 {name=l148 lab=m10}
C {devices/lab_pin.sym} 860.0 3320.0 0 0 {name=l149 lab=m11}
C {devices/lab_pin.sym} 860.0 3360.0 0 0 {name=l150 lab=t0}
C {devices/lab_pin.sym} 940.0 3300.0 0 0 {name=l151 lab=x0_5}
C {sky130_stdcells/mux2_1.sym} 1200 3300 0 0 {name=XM0_6 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1160.0 3280.0 0 0 {name=l152 lab=m12}
C {devices/lab_pin.sym} 1160.0 3320.0 0 0 {name=l153 lab=m13}
C {devices/lab_pin.sym} 1160.0 3360.0 0 0 {name=l154 lab=t0}
C {devices/lab_pin.sym} 1240.0 3300.0 0 0 {name=l155 lab=x0_6}
C {sky130_stdcells/mux2_1.sym} 1500 3300 0 0 {name=XM0_7 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1460.0 3280.0 0 0 {name=l156 lab=m14}
C {devices/lab_pin.sym} 1460.0 3320.0 0 0 {name=l157 lab=m15}
C {devices/lab_pin.sym} 1460.0 3360.0 0 0 {name=l158 lab=t0}
C {devices/lab_pin.sym} 1540.0 3300.0 0 0 {name=l159 lab=x0_7}
C {sky130_stdcells/mux2_1.sym} 0 3600 0 0 {name=XM0_8 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} -40.0 3580.0 0 0 {name=l160 lab=m16}
C {devices/lab_pin.sym} -40.0 3620.0 0 0 {name=l161 lab=m17}
C {devices/lab_pin.sym} -40.0 3660.0 0 0 {name=l162 lab=t0}
C {devices/lab_pin.sym} 40.0 3600.0 0 0 {name=l163 lab=x0_8}
C {sky130_stdcells/mux2_1.sym} 300 3600 0 0 {name=XM0_9 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 260.0 3580.0 0 0 {name=l164 lab=m18}
C {devices/lab_pin.sym} 260.0 3620.0 0 0 {name=l165 lab=m19}
C {devices/lab_pin.sym} 260.0 3660.0 0 0 {name=l166 lab=t0}
C {devices/lab_pin.sym} 340.0 3600.0 0 0 {name=l167 lab=x0_9}
C {sky130_stdcells/mux2_1.sym} 600 3600 0 0 {name=XM0_10 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 560.0 3580.0 0 0 {name=l168 lab=m20}
C {devices/lab_pin.sym} 560.0 3620.0 0 0 {name=l169 lab=m21}
C {devices/lab_pin.sym} 560.0 3660.0 0 0 {name=l170 lab=t0}
C {devices/lab_pin.sym} 640.0 3600.0 0 0 {name=l171 lab=x0_10}
C {sky130_stdcells/mux2_1.sym} 900 3600 0 0 {name=XM0_11 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 860.0 3580.0 0 0 {name=l172 lab=m22}
C {devices/lab_pin.sym} 860.0 3620.0 0 0 {name=l173 lab=m23}
C {devices/lab_pin.sym} 860.0 3660.0 0 0 {name=l174 lab=t0}
C {devices/lab_pin.sym} 940.0 3600.0 0 0 {name=l175 lab=x0_11}
C {sky130_stdcells/mux2_1.sym} 1200 3600 0 0 {name=XM0_12 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1160.0 3580.0 0 0 {name=l176 lab=m24}
C {devices/lab_pin.sym} 1160.0 3620.0 0 0 {name=l177 lab=m25}
C {devices/lab_pin.sym} 1160.0 3660.0 0 0 {name=l178 lab=t0}
C {devices/lab_pin.sym} 1240.0 3600.0 0 0 {name=l179 lab=x0_12}
C {sky130_stdcells/mux2_1.sym} 1500 3600 0 0 {name=XM0_13 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1460.0 3580.0 0 0 {name=l180 lab=m26}
C {devices/lab_pin.sym} 1460.0 3620.0 0 0 {name=l181 lab=m27}
C {devices/lab_pin.sym} 1460.0 3660.0 0 0 {name=l182 lab=t0}
C {devices/lab_pin.sym} 1540.0 3600.0 0 0 {name=l183 lab=x0_13}
C {sky130_stdcells/mux2_1.sym} 0 3900 0 0 {name=XM0_14 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} -40.0 3880.0 0 0 {name=l184 lab=m28}
C {devices/lab_pin.sym} -40.0 3920.0 0 0 {name=l185 lab=m29}
C {devices/lab_pin.sym} -40.0 3960.0 0 0 {name=l186 lab=t0}
C {devices/lab_pin.sym} 40.0 3900.0 0 0 {name=l187 lab=x0_14}
C {sky130_stdcells/mux2_1.sym} 300 3900 0 0 {name=XM0_15 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 260.0 3880.0 0 0 {name=l188 lab=m30}
C {devices/lab_pin.sym} 260.0 3920.0 0 0 {name=l189 lab=m31}
C {devices/lab_pin.sym} 260.0 3960.0 0 0 {name=l190 lab=t0}
C {devices/lab_pin.sym} 340.0 3900.0 0 0 {name=l191 lab=x0_15}
C {sky130_stdcells/mux2_1.sym} 600 3900 0 0 {name=XM0_16 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 560.0 3880.0 0 0 {name=l192 lab=m32}
C {devices/lab_pin.sym} 560.0 3920.0 0 0 {name=l193 lab=m33}
C {devices/lab_pin.sym} 560.0 3960.0 0 0 {name=l194 lab=t0}
C {devices/lab_pin.sym} 640.0 3900.0 0 0 {name=l195 lab=x0_16}
C {sky130_stdcells/mux2_1.sym} 900 3900 0 0 {name=XM0_17 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 860.0 3880.0 0 0 {name=l196 lab=m34}
C {devices/lab_pin.sym} 860.0 3920.0 0 0 {name=l197 lab=m35}
C {devices/lab_pin.sym} 860.0 3960.0 0 0 {name=l198 lab=t0}
C {devices/lab_pin.sym} 940.0 3900.0 0 0 {name=l199 lab=x0_17}
C {sky130_stdcells/mux2_1.sym} 1200 3900 0 0 {name=XM0_18 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1160.0 3880.0 0 0 {name=l200 lab=m36}
C {devices/lab_pin.sym} 1160.0 3920.0 0 0 {name=l201 lab=m37}
C {devices/lab_pin.sym} 1160.0 3960.0 0 0 {name=l202 lab=t0}
C {devices/lab_pin.sym} 1240.0 3900.0 0 0 {name=l203 lab=x0_18}
C {sky130_stdcells/mux2_1.sym} 1500 3900 0 0 {name=XM0_19 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1460.0 3880.0 0 0 {name=l204 lab=m38}
C {devices/lab_pin.sym} 1460.0 3920.0 0 0 {name=l205 lab=m39}
C {devices/lab_pin.sym} 1460.0 3960.0 0 0 {name=l206 lab=t0}
C {devices/lab_pin.sym} 1540.0 3900.0 0 0 {name=l207 lab=x0_19}
C {sky130_stdcells/mux2_1.sym} 0 4200 0 0 {name=XM0_20 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} -40.0 4180.0 0 0 {name=l208 lab=m40}
C {devices/lab_pin.sym} -40.0 4220.0 0 0 {name=l209 lab=m41}
C {devices/lab_pin.sym} -40.0 4260.0 0 0 {name=l210 lab=t0}
C {devices/lab_pin.sym} 40.0 4200.0 0 0 {name=l211 lab=x0_20}
C {sky130_stdcells/mux2_1.sym} 300 4200 0 0 {name=XM0_21 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 260.0 4180.0 0 0 {name=l212 lab=m42}
C {devices/lab_pin.sym} 260.0 4220.0 0 0 {name=l213 lab=m43}
C {devices/lab_pin.sym} 260.0 4260.0 0 0 {name=l214 lab=t0}
C {devices/lab_pin.sym} 340.0 4200.0 0 0 {name=l215 lab=x0_21}
C {sky130_stdcells/mux2_1.sym} 600 4200 0 0 {name=XM0_22 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 560.0 4180.0 0 0 {name=l216 lab=m44}
C {devices/lab_pin.sym} 560.0 4220.0 0 0 {name=l217 lab=m45}
C {devices/lab_pin.sym} 560.0 4260.0 0 0 {name=l218 lab=t0}
C {devices/lab_pin.sym} 640.0 4200.0 0 0 {name=l219 lab=x0_22}
C {sky130_stdcells/mux2_1.sym} 900 4200 0 0 {name=XM0_23 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 860.0 4180.0 0 0 {name=l220 lab=m46}
C {devices/lab_pin.sym} 860.0 4220.0 0 0 {name=l221 lab=m47}
C {devices/lab_pin.sym} 860.0 4260.0 0 0 {name=l222 lab=t0}
C {devices/lab_pin.sym} 940.0 4200.0 0 0 {name=l223 lab=x0_23}
C {sky130_stdcells/mux2_1.sym} 1200 4200 0 0 {name=XM0_24 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1160.0 4180.0 0 0 {name=l224 lab=m48}
C {devices/lab_pin.sym} 1160.0 4220.0 0 0 {name=l225 lab=m49}
C {devices/lab_pin.sym} 1160.0 4260.0 0 0 {name=l226 lab=t0}
C {devices/lab_pin.sym} 1240.0 4200.0 0 0 {name=l227 lab=x0_24}
C {sky130_stdcells/mux2_1.sym} 1500 4200 0 0 {name=XM0_25 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1460.0 4180.0 0 0 {name=l228 lab=m50}
C {devices/lab_pin.sym} 1460.0 4220.0 0 0 {name=l229 lab=m51}
C {devices/lab_pin.sym} 1460.0 4260.0 0 0 {name=l230 lab=t0}
C {devices/lab_pin.sym} 1540.0 4200.0 0 0 {name=l231 lab=x0_25}
C {sky130_stdcells/mux2_1.sym} 0 4500 0 0 {name=XM0_26 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} -40.0 4480.0 0 0 {name=l232 lab=m52}
C {devices/lab_pin.sym} -40.0 4520.0 0 0 {name=l233 lab=m53}
C {devices/lab_pin.sym} -40.0 4560.0 0 0 {name=l234 lab=t0}
C {devices/lab_pin.sym} 40.0 4500.0 0 0 {name=l235 lab=x0_26}
C {sky130_stdcells/mux2_1.sym} 300 4500 0 0 {name=XM0_27 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 260.0 4480.0 0 0 {name=l236 lab=m54}
C {devices/lab_pin.sym} 260.0 4520.0 0 0 {name=l237 lab=m55}
C {devices/lab_pin.sym} 260.0 4560.0 0 0 {name=l238 lab=t0}
C {devices/lab_pin.sym} 340.0 4500.0 0 0 {name=l239 lab=x0_27}
C {sky130_stdcells/mux2_1.sym} 600 4500 0 0 {name=XM0_28 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 560.0 4480.0 0 0 {name=l240 lab=m56}
C {devices/lab_pin.sym} 560.0 4520.0 0 0 {name=l241 lab=m57}
C {devices/lab_pin.sym} 560.0 4560.0 0 0 {name=l242 lab=t0}
C {devices/lab_pin.sym} 640.0 4500.0 0 0 {name=l243 lab=x0_28}
C {sky130_stdcells/mux2_1.sym} 900 4500 0 0 {name=XM0_29 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 860.0 4480.0 0 0 {name=l244 lab=m58}
C {devices/lab_pin.sym} 860.0 4520.0 0 0 {name=l245 lab=m59}
C {devices/lab_pin.sym} 860.0 4560.0 0 0 {name=l246 lab=t0}
C {devices/lab_pin.sym} 940.0 4500.0 0 0 {name=l247 lab=x0_29}
C {sky130_stdcells/mux2_1.sym} 1200 4500 0 0 {name=XM0_30 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1160.0 4480.0 0 0 {name=l248 lab=m60}
C {devices/lab_pin.sym} 1160.0 4520.0 0 0 {name=l249 lab=m61}
C {devices/lab_pin.sym} 1160.0 4560.0 0 0 {name=l250 lab=t0}
C {devices/lab_pin.sym} 1240.0 4500.0 0 0 {name=l251 lab=x0_30}
C {sky130_stdcells/mux2_1.sym} 1500 4500 0 0 {name=XM0_31 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1460.0 4480.0 0 0 {name=l252 lab=m62}
C {devices/lab_pin.sym} 1460.0 4520.0 0 0 {name=l253 lab=m63}
C {devices/lab_pin.sym} 1460.0 4560.0 0 0 {name=l254 lab=t0}
C {devices/lab_pin.sym} 1540.0 4500.0 0 0 {name=l255 lab=x0_31}
C {sky130_stdcells/mux2_1.sym} 0 4800 0 0 {name=XM1_0 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} -40.0 4780.0 0 0 {name=l256 lab=x0_0}
C {devices/lab_pin.sym} -40.0 4820.0 0 0 {name=l257 lab=x0_1}
C {devices/lab_pin.sym} -40.0 4860.0 0 0 {name=l258 lab=t1}
C {devices/lab_pin.sym} 40.0 4800.0 0 0 {name=l259 lab=x1_0}
C {sky130_stdcells/mux2_1.sym} 300 4800 0 0 {name=XM1_1 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 260.0 4780.0 0 0 {name=l260 lab=x0_2}
C {devices/lab_pin.sym} 260.0 4820.0 0 0 {name=l261 lab=x0_3}
C {devices/lab_pin.sym} 260.0 4860.0 0 0 {name=l262 lab=t1}
C {devices/lab_pin.sym} 340.0 4800.0 0 0 {name=l263 lab=x1_1}
C {sky130_stdcells/mux2_1.sym} 600 4800 0 0 {name=XM1_2 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 560.0 4780.0 0 0 {name=l264 lab=x0_4}
C {devices/lab_pin.sym} 560.0 4820.0 0 0 {name=l265 lab=x0_5}
C {devices/lab_pin.sym} 560.0 4860.0 0 0 {name=l266 lab=t1}
C {devices/lab_pin.sym} 640.0 4800.0 0 0 {name=l267 lab=x1_2}
C {sky130_stdcells/mux2_1.sym} 900 4800 0 0 {name=XM1_3 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 860.0 4780.0 0 0 {name=l268 lab=x0_6}
C {devices/lab_pin.sym} 860.0 4820.0 0 0 {name=l269 lab=x0_7}
C {devices/lab_pin.sym} 860.0 4860.0 0 0 {name=l270 lab=t1}
C {devices/lab_pin.sym} 940.0 4800.0 0 0 {name=l271 lab=x1_3}
C {sky130_stdcells/mux2_1.sym} 1200 4800 0 0 {name=XM1_4 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1160.0 4780.0 0 0 {name=l272 lab=x0_8}
C {devices/lab_pin.sym} 1160.0 4820.0 0 0 {name=l273 lab=x0_9}
C {devices/lab_pin.sym} 1160.0 4860.0 0 0 {name=l274 lab=t1}
C {devices/lab_pin.sym} 1240.0 4800.0 0 0 {name=l275 lab=x1_4}
C {sky130_stdcells/mux2_1.sym} 1500 4800 0 0 {name=XM1_5 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1460.0 4780.0 0 0 {name=l276 lab=x0_10}
C {devices/lab_pin.sym} 1460.0 4820.0 0 0 {name=l277 lab=x0_11}
C {devices/lab_pin.sym} 1460.0 4860.0 0 0 {name=l278 lab=t1}
C {devices/lab_pin.sym} 1540.0 4800.0 0 0 {name=l279 lab=x1_5}
C {sky130_stdcells/mux2_1.sym} 0 5100 0 0 {name=XM1_6 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} -40.0 5080.0 0 0 {name=l280 lab=x0_12}
C {devices/lab_pin.sym} -40.0 5120.0 0 0 {name=l281 lab=x0_13}
C {devices/lab_pin.sym} -40.0 5160.0 0 0 {name=l282 lab=t1}
C {devices/lab_pin.sym} 40.0 5100.0 0 0 {name=l283 lab=x1_6}
C {sky130_stdcells/mux2_1.sym} 300 5100 0 0 {name=XM1_7 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 260.0 5080.0 0 0 {name=l284 lab=x0_14}
C {devices/lab_pin.sym} 260.0 5120.0 0 0 {name=l285 lab=x0_15}
C {devices/lab_pin.sym} 260.0 5160.0 0 0 {name=l286 lab=t1}
C {devices/lab_pin.sym} 340.0 5100.0 0 0 {name=l287 lab=x1_7}
C {sky130_stdcells/mux2_1.sym} 600 5100 0 0 {name=XM1_8 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 560.0 5080.0 0 0 {name=l288 lab=x0_16}
C {devices/lab_pin.sym} 560.0 5120.0 0 0 {name=l289 lab=x0_17}
C {devices/lab_pin.sym} 560.0 5160.0 0 0 {name=l290 lab=t1}
C {devices/lab_pin.sym} 640.0 5100.0 0 0 {name=l291 lab=x1_8}
C {sky130_stdcells/mux2_1.sym} 900 5100 0 0 {name=XM1_9 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 860.0 5080.0 0 0 {name=l292 lab=x0_18}
C {devices/lab_pin.sym} 860.0 5120.0 0 0 {name=l293 lab=x0_19}
C {devices/lab_pin.sym} 860.0 5160.0 0 0 {name=l294 lab=t1}
C {devices/lab_pin.sym} 940.0 5100.0 0 0 {name=l295 lab=x1_9}
C {sky130_stdcells/mux2_1.sym} 1200 5100 0 0 {name=XM1_10 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1160.0 5080.0 0 0 {name=l296 lab=x0_20}
C {devices/lab_pin.sym} 1160.0 5120.0 0 0 {name=l297 lab=x0_21}
C {devices/lab_pin.sym} 1160.0 5160.0 0 0 {name=l298 lab=t1}
C {devices/lab_pin.sym} 1240.0 5100.0 0 0 {name=l299 lab=x1_10}
C {sky130_stdcells/mux2_1.sym} 1500 5100 0 0 {name=XM1_11 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1460.0 5080.0 0 0 {name=l300 lab=x0_22}
C {devices/lab_pin.sym} 1460.0 5120.0 0 0 {name=l301 lab=x0_23}
C {devices/lab_pin.sym} 1460.0 5160.0 0 0 {name=l302 lab=t1}
C {devices/lab_pin.sym} 1540.0 5100.0 0 0 {name=l303 lab=x1_11}
C {sky130_stdcells/mux2_1.sym} 0 5400 0 0 {name=XM1_12 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} -40.0 5380.0 0 0 {name=l304 lab=x0_24}
C {devices/lab_pin.sym} -40.0 5420.0 0 0 {name=l305 lab=x0_25}
C {devices/lab_pin.sym} -40.0 5460.0 0 0 {name=l306 lab=t1}
C {devices/lab_pin.sym} 40.0 5400.0 0 0 {name=l307 lab=x1_12}
C {sky130_stdcells/mux2_1.sym} 300 5400 0 0 {name=XM1_13 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 260.0 5380.0 0 0 {name=l308 lab=x0_26}
C {devices/lab_pin.sym} 260.0 5420.0 0 0 {name=l309 lab=x0_27}
C {devices/lab_pin.sym} 260.0 5460.0 0 0 {name=l310 lab=t1}
C {devices/lab_pin.sym} 340.0 5400.0 0 0 {name=l311 lab=x1_13}
C {sky130_stdcells/mux2_1.sym} 600 5400 0 0 {name=XM1_14 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 560.0 5380.0 0 0 {name=l312 lab=x0_28}
C {devices/lab_pin.sym} 560.0 5420.0 0 0 {name=l313 lab=x0_29}
C {devices/lab_pin.sym} 560.0 5460.0 0 0 {name=l314 lab=t1}
C {devices/lab_pin.sym} 640.0 5400.0 0 0 {name=l315 lab=x1_14}
C {sky130_stdcells/mux2_1.sym} 900 5400 0 0 {name=XM1_15 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 860.0 5380.0 0 0 {name=l316 lab=x0_30}
C {devices/lab_pin.sym} 860.0 5420.0 0 0 {name=l317 lab=x0_31}
C {devices/lab_pin.sym} 860.0 5460.0 0 0 {name=l318 lab=t1}
C {devices/lab_pin.sym} 940.0 5400.0 0 0 {name=l319 lab=x1_15}
C {sky130_stdcells/mux2_1.sym} 1200 5400 0 0 {name=XM2_0 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1160.0 5380.0 0 0 {name=l320 lab=x1_0}
C {devices/lab_pin.sym} 1160.0 5420.0 0 0 {name=l321 lab=x1_1}
C {devices/lab_pin.sym} 1160.0 5460.0 0 0 {name=l322 lab=t2}
C {devices/lab_pin.sym} 1240.0 5400.0 0 0 {name=l323 lab=x2_0}
C {sky130_stdcells/mux2_1.sym} 1500 5400 0 0 {name=XM2_1 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1460.0 5380.0 0 0 {name=l324 lab=x1_2}
C {devices/lab_pin.sym} 1460.0 5420.0 0 0 {name=l325 lab=x1_3}
C {devices/lab_pin.sym} 1460.0 5460.0 0 0 {name=l326 lab=t2}
C {devices/lab_pin.sym} 1540.0 5400.0 0 0 {name=l327 lab=x2_1}
C {sky130_stdcells/mux2_1.sym} 0 5700 0 0 {name=XM2_2 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} -40.0 5680.0 0 0 {name=l328 lab=x1_4}
C {devices/lab_pin.sym} -40.0 5720.0 0 0 {name=l329 lab=x1_5}
C {devices/lab_pin.sym} -40.0 5760.0 0 0 {name=l330 lab=t2}
C {devices/lab_pin.sym} 40.0 5700.0 0 0 {name=l331 lab=x2_2}
C {sky130_stdcells/mux2_1.sym} 300 5700 0 0 {name=XM2_3 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 260.0 5680.0 0 0 {name=l332 lab=x1_6}
C {devices/lab_pin.sym} 260.0 5720.0 0 0 {name=l333 lab=x1_7}
C {devices/lab_pin.sym} 260.0 5760.0 0 0 {name=l334 lab=t2}
C {devices/lab_pin.sym} 340.0 5700.0 0 0 {name=l335 lab=x2_3}
C {sky130_stdcells/mux2_1.sym} 600 5700 0 0 {name=XM2_4 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 560.0 5680.0 0 0 {name=l336 lab=x1_8}
C {devices/lab_pin.sym} 560.0 5720.0 0 0 {name=l337 lab=x1_9}
C {devices/lab_pin.sym} 560.0 5760.0 0 0 {name=l338 lab=t2}
C {devices/lab_pin.sym} 640.0 5700.0 0 0 {name=l339 lab=x2_4}
C {sky130_stdcells/mux2_1.sym} 900 5700 0 0 {name=XM2_5 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 860.0 5680.0 0 0 {name=l340 lab=x1_10}
C {devices/lab_pin.sym} 860.0 5720.0 0 0 {name=l341 lab=x1_11}
C {devices/lab_pin.sym} 860.0 5760.0 0 0 {name=l342 lab=t2}
C {devices/lab_pin.sym} 940.0 5700.0 0 0 {name=l343 lab=x2_5}
C {sky130_stdcells/mux2_1.sym} 1200 5700 0 0 {name=XM2_6 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1160.0 5680.0 0 0 {name=l344 lab=x1_12}
C {devices/lab_pin.sym} 1160.0 5720.0 0 0 {name=l345 lab=x1_13}
C {devices/lab_pin.sym} 1160.0 5760.0 0 0 {name=l346 lab=t2}
C {devices/lab_pin.sym} 1240.0 5700.0 0 0 {name=l347 lab=x2_6}
C {sky130_stdcells/mux2_1.sym} 1500 5700 0 0 {name=XM2_7 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1460.0 5680.0 0 0 {name=l348 lab=x1_14}
C {devices/lab_pin.sym} 1460.0 5720.0 0 0 {name=l349 lab=x1_15}
C {devices/lab_pin.sym} 1460.0 5760.0 0 0 {name=l350 lab=t2}
C {devices/lab_pin.sym} 1540.0 5700.0 0 0 {name=l351 lab=x2_7}
C {sky130_stdcells/mux2_1.sym} 0 6000 0 0 {name=XM3_0 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} -40.0 5980.0 0 0 {name=l352 lab=x2_0}
C {devices/lab_pin.sym} -40.0 6020.0 0 0 {name=l353 lab=x2_1}
C {devices/lab_pin.sym} -40.0 6060.0 0 0 {name=l354 lab=t3}
C {devices/lab_pin.sym} 40.0 6000.0 0 0 {name=l355 lab=x3_0}
C {sky130_stdcells/mux2_1.sym} 300 6000 0 0 {name=XM3_1 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 260.0 5980.0 0 0 {name=l356 lab=x2_2}
C {devices/lab_pin.sym} 260.0 6020.0 0 0 {name=l357 lab=x2_3}
C {devices/lab_pin.sym} 260.0 6060.0 0 0 {name=l358 lab=t3}
C {devices/lab_pin.sym} 340.0 6000.0 0 0 {name=l359 lab=x3_1}
C {sky130_stdcells/mux2_1.sym} 600 6000 0 0 {name=XM3_2 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 560.0 5980.0 0 0 {name=l360 lab=x2_4}
C {devices/lab_pin.sym} 560.0 6020.0 0 0 {name=l361 lab=x2_5}
C {devices/lab_pin.sym} 560.0 6060.0 0 0 {name=l362 lab=t3}
C {devices/lab_pin.sym} 640.0 6000.0 0 0 {name=l363 lab=x3_2}
C {sky130_stdcells/mux2_1.sym} 900 6000 0 0 {name=XM3_3 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 860.0 5980.0 0 0 {name=l364 lab=x2_6}
C {devices/lab_pin.sym} 860.0 6020.0 0 0 {name=l365 lab=x2_7}
C {devices/lab_pin.sym} 860.0 6060.0 0 0 {name=l366 lab=t3}
C {devices/lab_pin.sym} 940.0 6000.0 0 0 {name=l367 lab=x3_3}
C {sky130_stdcells/mux2_1.sym} 1200 6000 0 0 {name=XM4_0 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1160.0 5980.0 0 0 {name=l368 lab=x3_0}
C {devices/lab_pin.sym} 1160.0 6020.0 0 0 {name=l369 lab=x3_1}
C {devices/lab_pin.sym} 1160.0 6060.0 0 0 {name=l370 lab=t4}
C {devices/lab_pin.sym} 1240.0 6000.0 0 0 {name=l371 lab=x4_0}
C {sky130_stdcells/mux2_1.sym} 1500 6000 0 0 {name=XM4_1 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 1460.0 5980.0 0 0 {name=l372 lab=x3_2}
C {devices/lab_pin.sym} 1460.0 6020.0 0 0 {name=l373 lab=x3_3}
C {devices/lab_pin.sym} 1460.0 6060.0 0 0 {name=l374 lab=t4}
C {devices/lab_pin.sym} 1540.0 6000.0 0 0 {name=l375 lab=x4_1}
C {sky130_stdcells/mux2_1.sym} 0 6300 0 0 {name=XM5_0 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} -40.0 6280.0 0 0 {name=l376 lab=x4_0}
C {devices/lab_pin.sym} -40.0 6320.0 0 0 {name=l377 lab=x4_1}
C {devices/lab_pin.sym} -40.0 6360.0 0 0 {name=l378 lab=t5}
C {devices/lab_pin.sym} 40.0 6300.0 0 0 {name=l379 lab=rst_d}
C {sky130_stdcells/nor2_1.sym} 300 6300 0 0 {name=XL1 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 240.0 6280.0 0 0 {name=l380 lab=rst_d}
C {devices/lab_pin.sym} 240.0 6320.0 0 0 {name=l381 lab=qb}
C {devices/lab_pin.sym} 360.0 6300.0 0 0 {name=l382 lab=hs_pwm}
C {sky130_stdcells/nor2_1.sym} 600 6300 0 0 {name=XL2 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__}
C {devices/lab_pin.sym} 540.0 6280.0 0 0 {name=l383 lab=pwm_set}
C {devices/lab_pin.sym} 540.0 6320.0 0 0 {name=l384 lab=hs_pwm}
C {devices/lab_pin.sym} 660.0 6300.0 0 0 {name=l385 lab=qb}
